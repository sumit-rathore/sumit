_icron_no_counter_</spirit:description>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>16</spirit:bitWidth>
                              <spirit:volatile>true</spirit:volatile>
                              <spirit:access>read-only</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0000000000000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x8000307C</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>pfifo_dcount</spirit:name>
                           <spirit:description>Current level for the packet FIFO in the PFIFO</spirit:description>
                           <spirit:addressOffset>0x8</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>pfifo_dcount</spirit:name>
                              <spirit:description>_icron_water_marker_
_icron_no_counter_</spirit:description>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>16</spirit:bitWidth>
                              <spirit:volatile>true</spirit:volatile>
                              <spirit:access>read-only</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0000000000000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x80003080</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>pkt_max_byte_cnt_err</spirit:name>
                           <spirit:description>The count for capped packets in PFIFO write engine, as the result of reaching maximum size in the PFIFO</spirit:description>
                           <spirit:addressOffset>0xC</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>pkt_max_byte_cnt_err</spirit:name>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>8</spirit:bitWidth>
                              <spirit:volatile>true</spirit:volatile>
                              <spirit:access>read-only</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>00000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x80003084</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>fifo_full_err</spirit:name>
                           <spirit:description>The count for either of PFIFO or NFIFO being full</spirit:description>
                           <spirit:addressOffset>0x10</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>fifo_full_err</spirit:name>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>8</spirit:bitWidth>
                              <spirit:volatile>true</spirit:volatile>
                              <spirit:access>read-only</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>00000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x80003088</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>pkt_err</spirit:name>
                           <spirit:description>The count of packets tagged to be dropped later in the PFIFO read engine</spirit:description>
                           <spirit:addressOffset>0x14</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>pkt_err</spirit:name>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>8</spirit:bitWidth>
                              <spirit:volatile>true</spirit:volatile>
                              <spirit:access>read-only</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>00000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x8000308C</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>pkt_sop_err</spirit:name>
                           <spirit:description>The count of packets flushed in the PFIFO during the SOP phase</spirit:description>
                           <spirit:addressOffset>0x18</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>pkt_sop_err</spirit:name>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>8</spirit:bitWidth>
                              <spirit:volatile>true</spirit:volatile>
                              <spirit:access>read-only</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>00000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x80003090</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>wflush_act</spirit:name>
                           <spirit:description>The count of capped packets in the PFIFO. Note that back-to-back packets are counted as one if they are both capped.</spirit:description>
                           <spirit:addressOffset>0x1C</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>wflush_act</spirit:name>
                              <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>8</spirit:bitWidth>
                              <spirit:volatile>true</spirit:volatile>
                              <spirit:access>read-only</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>00000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x80003094</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>drp_pkt_rd</spirit:name>
                           <spirit:description>The count of drop packets flagged to be dropped by the read engine</spirit:description>
                           <spirit:addressOffset>0x20</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>drp_pkt_rd</spirit:name>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>8</spirit:bitWidth>
                              <spirit:volatile>true</spirit:volatile>
                              <spirit:access>read-only</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>00000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x80003098</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>drp_pkt_wr</spirit:name>
                           <spirit:description>The count of drop packets by the write engine</spirit:description>
                           <spirit:addressOffset>0x24</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>drp_pkt_wr</spirit:name>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>8</spirit:bitWidth>
                              <spirit:volatile>true</spirit:volatile>
                              <spirit:access>read-only</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>00000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x8000309C</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:description>The count of the clock cycles the DRDY is asserted low resulting in flow control</spirit:description>
                           <spirit:addressOffset>0x28</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>flow_ctrl</spirit:name>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>16</spirit:bitWidth>
                              <spirit:volatile>true</spirit:volatile>
                              <spirit:access>read-only</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0000000000000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x800030A0</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80003078</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 
<spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x8000306C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : write_engine  --> 

  <!-- reg group
                    :read_engine  --> 
          <spirit:registerFile>
                     <spirit:name>read_engine</spirit:name>
                     <spirit:addressOffset>0x3C</spirit:addressOffset>
                     <spirit:range>0x14</spirit:range>
  <!-- reg group
                    :config0  --> 
          <spirit:registerFile>
                        <spirit:name>config0</spirit:name>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:range>0x4</spirit:range>            
                        <spirit:register>
                           <spirit:name>clear</spirit:name>
                           <spirit:description>Synchronous clear for the read clock domain</spirit:description>
                           <spirit:addressOffset>0x0</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>rclr</spirit:name>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <address>0x800030A4</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x800030A4</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:registerFile>  <!-- end
                of reg group : config0  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                        <spirit:name>stats0</spirit:name>
                        <spirit:description>All the Statistic Registers and their configuration for the Read Engine</spirit:description>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:range>0x10</spirit:range>            
                        <spirit:register>
                           <spirit:name>rd2clr_config</spirit:name>
                           <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                           <spirit:addressOffset>0x0</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>flow_ctrl</spirit:name>
                              <spirit:bitOffset>2</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>drp_pkt</spirit:name>
                              <spirit:bitOffset>1</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>rflush_act</spirit:name>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x800030A8</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>rflush_act</spirit:name>
                           <spirit:description>The counts of number of packets flushed from the PFIFO.</spirit:description>
                           <spirit:addressOffset>0x4</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>rflush_act</spirit:name>
                              <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>8</spirit:bitWidth>
                              <spirit:volatile>true</spirit:volatile>
                              <spirit:access>read-only</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>00000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x800030AC</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>drp_pkt</spirit:name>
                           <spirit:description>The counts of drop packet in the PFIFO read engine</spirit:description>
                           <spirit:addressOffset>0x8</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>drp_pkt</spirit:name>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>8</spirit:bitWidth>
                              <spirit:volatile>true</spirit:volatile>
                              <spirit:access>read-only</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>00000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x800030B0</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:description>The count of the clock cycles the DRDY is asserted low resulting in flow control</spirit:description>
                           <spirit:addressOffset>0xC</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>flow_ctrl</spirit:name>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>16</spirit:bitWidth>
                              <spirit:volatile>true</spirit:volatile>
                              <spirit:access>read-only</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0000000000000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x800030B4</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x800030A8</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 
<spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x800030A4</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : read_engine  --> 
<spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003068</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : pfifo  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                  <spirit:name>stats0</spirit:name>
                  <spirit:description>All the Statistic Registers and their configuration for the GMII</spirit:description>
                  <spirit:addressOffset>0x58</spirit:addressOffset>
                  <spirit:range>0xC</spirit:range>            
                  <spirit:register>
                     <spirit:name>rd2clr_config</spirit:name>
                     <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>inbuff_sop</spirit:name>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>inbuff_eop</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x800030B8</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>inbuff_eop</spirit:name>
                     <spirit:description>Count of the PTP EOP saved into the buffer</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>inbuff_eop</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x800030BC</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>inbuff_sop</spirit:name>
                     <spirit:description>Count of the PTP SOP saved into the buffer</spirit:description>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>inbuff_sop</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x800030C0</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800030B8</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 

  <!-- reg group
                    :stats1  --> 
          <spirit:registerFile>
                  <spirit:name>stats1</spirit:name>
                  <spirit:description>All the Statistic Registers and their configuration for the GMII</spirit:description>
                  <spirit:addressOffset>0x64</spirit:addressOffset>
                  <spirit:range>0x14</spirit:range>            
                  <spirit:register>
                     <spirit:name>rd2clr_config</spirit:name>
                     <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>gmii_start</spirit:name>
                        <spirit:bitOffset>3</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>gmii_done</spirit:name>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>gmii_outbuff_sop</spirit:name>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>gmii_outbuff_eop</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x800030C4</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>gmii_outbuff_eop</spirit:name>
                     <spirit:description>Count of the PTP EOP after the buffer and seen on the GMII output port</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>gmii_out_eop</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x800030C8</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>gmii_outbuff_sop</spirit:name>
                     <spirit:description>Count of the PTP SOP after the buffer and seen on the GMII output port</spirit:description>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>gmii_outbuff_sop</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x800030CC</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>gmii_done</spirit:name>
                     <spirit:description>Count of the GMII FSM completing a packet and after an IFG period is also completed</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>gmii_done</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x800030D0</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>gmii_start</spirit:name>
                     <spirit:description>Count of the GMII FSM starting to process a packet</spirit:description>
                     <spirit:addressOffset>0x10</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>gmii_start</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x800030D4</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800030C4</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : stats1  --> 

  <!-- reg group
                    :stats2  --> 
          <spirit:registerFile>
                  <spirit:name>stats2</spirit:name>
                  <spirit:description>All the Statistic Registers and their configuration for the XGMII</spirit:description>
                  <spirit:addressOffset>0x78</spirit:addressOffset>
                  <spirit:range>0x14</spirit:range>            
                  <spirit:register>
                     <spirit:name>rd2clr_config</spirit:name>
                     <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>xgmii_start</spirit:name>
                        <spirit:bitOffset>3</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>xgmii_done</spirit:name>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>xgmii_outbuff_sop</spirit:name>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>xgmii_outbuff_eop</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x800030D8</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>xgmii_outbuff_eop</spirit:name>
                     <spirit:description>Count of the PTP EOP after the buffer and seen on the XGMII output port</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>xgmii_out_eop</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x800030DC</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>xgmii_outbuff_sop</spirit:name>
                     <spirit:description>Count of the PTP SOP after the buffer and seen on the XGMII output port</spirit:description>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>xgmii_outbuff_sop</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x800030E0</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>xgmii_done</spirit:name>
                     <spirit:description>Count of the XGMII FSM completing a packet and after an IFG period is also completed</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>xgmii_done</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x800030E4</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>xgmii_start</spirit:name>
                     <spirit:description>Count of the XGMII FSM starting to process a packet</spirit:description>
                     <spirit:addressOffset>0x10</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>xgmii_start</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x800030E8</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800030D8</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : stats2  --> 
<spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80003060</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : media_rs  --> 

  <!-- reg group
                    :ptp_guard  --> 
          <spirit:registerFile>
               <spirit:name>ptp_guard</spirit:name>
               <spirit:addressOffset>0xEC</spirit:addressOffset>
               <spirit:range>0x2C</spirit:range>            
               <spirit:register>
                  <spirit:name>version</spirit:name>
                  <spirit:description>3.1.0: Fixed bug in Max Cycle Error where in certain mode the cycles were included in the count
3.2.0: Changed the Interrupt Pending to avoid blocking the register update when enable is 0
3.3.0: Added pending_irq register</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00030300</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>major</spirit:name>
                     <spirit:description>Major version</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000011</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>minor</spirit:name>
                     <spirit:description>Minor version</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000011</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>patch</spirit:name>
                     <spirit:description>Patch version</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800030EC</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
  <!-- reg group
                    :config0  --> 
          <spirit:registerFile>
                  <spirit:name>config0</spirit:name>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:range>0x8</spirit:range>            
                  <spirit:register>
                     <spirit:name>fix_ptp_violations</spirit:name>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000001</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>implemented</spirit:name>
                        <spirit:description>This is the synthesis parameter value used. When 1, it shows the PTP Guard fix logic has been implemented</spirit:description>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>activate</spirit:name>
                        <spirit:description>When 1, and if the fix logic is implemented, it instructs the PTP Guard to fix the PTP violations it detects (and reports). Note that there is a synthesis parameter to generate the "fix" logic or not

When 0, no attempt is done to fix (even if the logic exists) and the PTP Guard will only work as a monitor and reports the violations detected.

For full details of the operation, what violations are detected and fixed, and how the fix is done, see the wiki.</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>1</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x800030F0</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>max_cycles</spirit:name>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00030000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_mode</spirit:name>
                        <spirit:description>This configures the mode of counting towards max_cycles:

0x0: All PTP cycles are included in the count
0x1: PTP cycles with backpressure (drdy=1'b0) are excluded from the count
0x2: PTP cycles with wait (srdy=1'b0) are excluded from the count
0x3: PTP cycles with either backpressure or wait are excluded from the count. Hence, only "absorbed" PTP cycles are included in the count

Other mode values are reserved</spirit:description>
                        <spirit:bitOffset>16</spirit:bitOffset>
                        <spirit:bitWidth>4</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0011</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>max_cycles</spirit:name>
                        <spirit:description>Sets the maximum number of clock cycles the PTP packet can last between its sop and eop taking into account the max_cycle_mode

When set to 0, it instructs the logic not to fix this violation (when the fix logic is available). However, the monitor will still issue a violation when the cycle count reaches its maximum and rollover.</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x800030F4</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800030F0</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : config0  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                  <spirit:name>stats0</spirit:name>
                  <spirit:description>All the Statistic Registers and their configuration</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:range>0x10</spirit:range>            
                  <spirit:register>
                     <spirit:name>rd2clr_config</spirit:name>
                     <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_err</spirit:name>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_eop_err</spirit:name>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_sop_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x800030F8</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>missing_sop_err</spirit:name>
                     <spirit:description>Counts the number of PTP violations due to missing sop where the srdy was asserted without a prior sop assertion</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>missing_sop_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x800030FC</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>missing_eop_err</spirit:name>
                     <spirit:description>Counts the number of PTP violations due to missing eop where the PTP had been started but a new sop is seen without ending the previously started PTP</spirit:description>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>missing_eop_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003100</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>max_cycle_err</spirit:name>
                     <spirit:description>Counts the number of PTP violations due to reaching the maximum allowed cycles after starting a new PTP</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003104</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800030F8</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 

  <!-- reg group
                    :irq0  --> 
          <spirit:registerFile>
                  <spirit:name>irq0</spirit:name>
                  <spirit:description>Define the IRQ group</spirit:description>
                  <spirit:addressOffset>0x1C</spirit:addressOffset>
                  <spirit:range>0x10</spirit:range>            
                  <spirit:register>
                     <spirit:name>enable</spirit:name>
                     <spirit:description>The enable for the actual interrupt signals. Writing a 1 enables the interrupt.
</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_err</spirit:name>
                        <spirit:description>Fires on PTP violations due to reaching the maximum allowed cycles after starting a new PTP</spirit:description>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_eop_err</spirit:name>
                        <spirit:description>Fires on PTP violations due to missing eop where the PTP had been started but a new sop is seen without ending the previously started PTP</spirit:description>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_sop_err</spirit:name>
                        <spirit:description>Fires on PTP violations due to missing sop where the srdy was asserted without a prior sop assertion</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003108</address>
                           <intr.enable>irq666_ptp_guard</intr.enable>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>pending</spirit:name>
                     <spirit:description>The actual interrupt(s) that has triggered. Write a 1 to clear.
</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_err</spirit:name>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_eop_err</spirit:name>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_sop_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x8000310C</address>
                           <intr.status>irq666_ptp_guard</intr.status>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>pending_irq</spirit:name>
                     <spirit:description>Registered version of pending &amp; enable.
</spirit:description>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_err</spirit:name>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_eop_err</spirit:name>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_sop_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003110</address>
                           <intr.pending>irq666_ptp_guard</intr.pending>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>raw</spirit:name>
                     <spirit:description>The status registered values for the interrupt signals, if applicable.</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_err</spirit:name>
                        <spirit:description>Not used</spirit:description>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_eop_err</spirit:name>
                        <spirit:description>Not used</spirit:description>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_sop_err</spirit:name>
                        <spirit:description>Not used</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003114</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003108</address>
                        <context>ptp_guard</context>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : irq0  --> 
<spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x800030EC</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : ptp_guard  --> 

  <!-- reg group
                    :self_test_support  --> 
          <spirit:registerFile>
               <spirit:name>self_test_support</spirit:name>
               <spirit:addressOffset>0x118</spirit:addressOffset>
               <spirit:range>0x20</spirit:range>            
               <spirit:register>
                  <spirit:name>set_up</spirit:name>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000001</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>enable</spirit:name>
                     <spirit:description>Connects CH0 to the self-test logic when it is 0x1, provided the proper parameter (p_impl_self_test) is set to "YES"</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003118</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
  <!-- reg group
                    :media_gen  --> 
          <spirit:registerFile>
                  <spirit:name>media_gen</spirit:name>
                  <spirit:description>Registers needed for the Media Generator needed for self-test</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:range>0x8</spirit:range>            
                  <spirit:register>
                     <spirit:name>version</spirit:name>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:reset>
                        <spirit:value>0x00010000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>major</spirit:name>
                        <spirit:description>Major version</spirit:description>
                        <spirit:bitOffset>16</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000001</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>minor</spirit:name>
                        <spirit:description>Minor version</spirit:description>
                        <spirit:bitOffset>8</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>patch</spirit:name>
                        <spirit:description>Patch version</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x8000311C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>mca_mgen</spirit:name>
                     <spirit:description>Media generator configuration register</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000190</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>iwg_cnt</spirit:name>
                        <spirit:description>Media generator inter-word count select. This is the number of srdy "not ready" (srdy = 1'b0) cycles that can be inserted between words.

0 = 0 cycles
1 = 1 cycle
2 = 2 cycles
3 = 0-3 cycles</spirit:description>
                        <spirit:bitOffset>10</spirit:bitOffset>
                        <spirit:bitWidth>2</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>ifg_cnt</spirit:name>
                        <spirit:description>Media generator inter-frame count select. This is the number of clock cycles that can be inserted between packets.

0 = 0 cycles
1 = 1 cycle
2 = 1023 cycles
3 = rdm 1-1023 cycles</spirit:description>
                        <spirit:bitOffset>8</spirit:bitOffset>
                        <spirit:bitWidth>2</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>01</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>pkt_cnt</spirit:name>
                        <spirit:description>Media generator packet count select.

0 = constant - set ConfigMgenX.Go='0' to stop.
1 = 1 time
2 = 1024 times
3 = 65535 times</spirit:description>
                        <spirit:bitOffset>6</spirit:bitOffset>
                        <spirit:bitWidth>2</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>10</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>pkt_size</spirit:name>
                        <spirit:description>Media generator packet size select.

0 = fix 10 bytes
1 = fix 1000 bytes
2 = inc 1-1023 bytes
3 = rdm 1-1023 bytes</spirit:description>
                        <spirit:bitOffset>4</spirit:bitOffset>
                        <spirit:bitWidth>2</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>01</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>throttle</spirit:name>
                        <spirit:description>Media generator throttle enable. Allows CPU to control media generator transmitter source ready (srdy).

0 = srdy with/without drdy (may cause loss of traffic)
1 = srdy with drdy</spirit:description>
                        <spirit:bitOffset>3</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>mode</spirit:name>
                        <spirit:description>Media generator traffic mode select. 

0 = incrementing data
1 = random data</spirit:description>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>enable</spirit:name>
                        <spirit:description>Media generator enable. Must be set '0' if the corresponding media is trying to connect to the pipe. Can also be set '0' to stop a media generator that is set for continuous mode. Set '1' if setting go '1'.

0 = disabled
1 = enabled</spirit:description>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>go</spirit:name>
                        <spirit:description>Go/Busy (Cleared by HW)
</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                           <ids_properties>
                              <rtl.hw_clear>1</rtl.hw_clear>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003120</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000311C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : media_gen  --> 

  <!-- reg group
                    :framer  --> 
          <spirit:registerFile>
                  <spirit:name>framer</spirit:name>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:range>0x14</spirit:range>            
                  <spirit:register>
                     <spirit:name>max_byte</spirit:name>
                     <spirit:description>Maximum bytes in incoming PTP bytes</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000080</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_byte</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>14</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000010000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003124</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>mac_dg_type</spirit:name>
                     <spirit:description>MAC Datagram Type used in the out PTP</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000004</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>mac_dg_type</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000100</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003128</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>timer_wait</spirit:name>
                     <spirit:description>Maximum number of clock cycles that is allowed to hold a new incoming PTP before it is put into a MAC Datagram if the input PTPs are not back-to-back and the downstream is not busy. The timer starts when a new PTP is received. This timer gives a control of aggregating input PTPs that are gapped.

Note: A value of 0x0 instructs the logic to not wait for input PTPs if they are gapped, unless the downstream is busy in which case the logic will always wait for gapped input PTPs unless the next PTP has the "potential" to go over the MTU size</spirit:description>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>timer_wait</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>12</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x8000312C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>mtu_size</spirit:name>
                     <spirit:description>This is the MTU size to use. 

Note that the FPGA build must have been built with the highest of normal MTU=1500 or Jumbo MTU=9000 (see max_mtu_size). Accordingly, this value should be less than that.</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x000005DC</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>mtu_size</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>14</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00010111011100</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003130</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>max_mtu_size</spirit:name>
                     <spirit:description>This is the MTU size used during the FPGA build.</spirit:description>
                     <spirit:addressOffset>0x10</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x000005DC</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_mtu_size</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>14</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00010111011100</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003134</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003124</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : framer  --> 
<spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80003118</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : self_test_support  --> 
            <spirit:register>
               <spirit:name>control</spirit:name>
               <spirit:addressOffset>0x138</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>force_xgmii_rf</spirit:name>
                  <spirit:description>Instructs the Link Layer TX to send Remote Fault order-set on the XGMII. 

This control provides a back-door to Link Fault Signaling that is normally taken care of by the FPGA, and is mutually exclusive with force_xgmii_idle.</spirit:description>
                  <spirit:bitOffset>1</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>force_xgmii_idle</spirit:name>
                  <spirit:description>Instructs the Link Layer TX to send Idle Character on the XGMII. 

This control provides a back-door to Link Fault Signaling that is normally taken care of by the FPGA, and is mutually exclusive with force_xgmii_rf.</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80003138</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>
  <!-- reg group
                    :irq0  --> 
          <spirit:registerFile>
               <spirit:name>irq0</spirit:name>
               <spirit:description>Define the IRQ group</spirit:description>
               <spirit:addressOffset>0x13C</spirit:addressOffset>
               <spirit:range>0x10</spirit:range>            
               <spirit:register>
                  <spirit:name>enable</spirit:name>
                  <spirit:description>Indicating a rollover for that particular count has occurred
</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>mac_pause_frame_irq_rollover</spirit:name>
                     <spirit:bitOffset>28</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mac_out_eop_irq_rollover</spirit:name>
                     <spirit:bitOffset>27</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mac_out_sop_irq_rollover</spirit:name>
                     <spirit:bitOffset>26</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mac_stall_ptp_in_irq_rollover</spirit:name>
                     <spirit:bitOffset>25</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mac_in_eop_irq_rollover</spirit:name>
                     <spirit:bitOffset>24</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mac_in_sop_irq_rollover</spirit:name>
                     <spirit:bitOffset>23</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mac_fsm_count_beyond_ptp_irq_rollover</spirit:name>
                     <spirit:bitOffset>22</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mac_fsm_rollover_irq_rollover</spirit:name>
                     <spirit:bitOffset>21</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_nfifo_dcount_irq_rollover</spirit:name>
                     <spirit:bitOffset>20</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_pfifo_dcount_irq_rollover</spirit:name>
                     <spirit:bitOffset>19</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_pkt_max_byte_cnt_err_irq_rollover</spirit:name>
                     <spirit:bitOffset>18</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_fifo_full_err_irq_rollover</spirit:name>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_pkt_err_irq_rollover</spirit:name>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_pkt_sop_err_irq_rollover</spirit:name>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_wflush_act_irq_rollover</spirit:name>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_drp_pkt_rd_irq_rollover</spirit:name>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_drp_pkt_wr_irq_rollover</spirit:name>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_rflush_act_irq_rollover</spirit:name>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_drp_pkt_irq_rollover</spirit:name>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_inbuff_eop_irq_rollover</spirit:name>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_inbuff_sop_irq_rollover</spirit:name>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_gmii_outbuff_eop_irq_rollover</spirit:name>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_gmii_outbuff_sop_irq_rollover</spirit:name>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_gmii_done_irq_rollover</spirit:name>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_gmii_start_irq_rollover</spirit:name>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_xgmii_outbuff_eop_irq_rollover</spirit:name>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_xgmii_outbuff_sop_irq_rollover</spirit:name>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_xgmii_done_irq_rollover</spirit:name>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_xgmii_start_irq_rollover</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000313C</address>
                        <intr.enable>irq0_link_layer_tx</intr.enable>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending</spirit:name>
                  <spirit:description>Indicating a rollover for that particular count has occurred
</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>mac_pause_frame_irq_rollover</spirit:name>
                     <spirit:bitOffset>28</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mac_out_eop_irq_rollover</spirit:name>
                     <spirit:bitOffset>27</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mac_out_sop_irq_rollover</spirit:name>
                     <spirit:bitOffset>26</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mac_stall_ptp_in_irq_rollover</spirit:name>
                     <spirit:bitOffset>25</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mac_in_eop_irq_rollover</spirit:name>
                     <spirit:bitOffset>24</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mac_in_sop_irq_rollover</spirit:name>
                     <spirit:bitOffset>23</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mac_fsm_count_beyond_ptp_irq_rollover</spirit:name>
                     <spirit:bitOffset>22</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mac_fsm_rollover_irq_rollover</spirit:name>
                     <spirit:bitOffset>21</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_nfifo_dcount_irq_rollover</spirit:name>
                     <spirit:bitOffset>20</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_pfifo_dcount_irq_rollover</spirit:name>
                     <spirit:bitOffset>19</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_pkt_max_byte_cnt_err_irq_rollover</spirit:name>
                     <spirit:bitOffset>18</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_fifo_full_err_irq_rollover</spirit:name>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_pkt_err_irq_rollover</spirit:name>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_pkt_sop_err_irq_rollover</spirit:name>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_wflush_act_irq_rollover</spirit:name>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_drp_pkt_rd_irq_rollover</spirit:name>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_drp_pkt_wr_irq_rollover</spirit:name>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_rflush_act_irq_rollover</spirit:name>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_drp_pkt_irq_rollover</spirit:name>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_inbuff_eop_irq_rollover</spirit:name>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_inbuff_sop_irq_rollover</spirit:name>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_gmii_outbuff_eop_irq_rollover</spirit:name>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_gmii_outbuff_sop_irq_rollover</spirit:name>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_gmii_done_irq_rollover</spirit:name>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_gmii_start_irq_rollover</spirit:name>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_xgmii_outbuff_eop_irq_rollover</spirit:name>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_xgmii_outbuff_sop_irq_rollover</spirit:name>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_xgmii_done_irq_rollover</spirit:name>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_xgmii_start_irq_rollover</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003140</address>
                        <intr.status>irq0_link_layer_tx</intr.status>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending_irq</spirit:name>
                  <spirit:description>Registered version of pending &amp; enable
</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>mac_pause_frame_irq_rollover</spirit:name>
                     <spirit:bitOffset>28</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mac_out_eop_irq_rollover</spirit:name>
                     <spirit:bitOffset>27</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mac_out_sop_irq_rollover</spirit:name>
                     <spirit:bitOffset>26</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mac_stall_ptp_in_irq_rollover</spirit:name>
                     <spirit:bitOffset>25</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mac_in_eop_irq_rollover</spirit:name>
                     <spirit:bitOffset>24</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mac_in_sop_irq_rollover</spirit:name>
                     <spirit:bitOffset>23</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mac_fsm_count_beyond_ptp_irq_rollover</spirit:name>
                     <spirit:bitOffset>22</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mac_fsm_rollover_irq_rollover</spirit:name>
                     <spirit:bitOffset>21</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_nfifo_dcount_irq_rollover</spirit:name>
                     <spirit:bitOffset>20</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_pfifo_dcount_irq_rollover</spirit:name>
                     <spirit:bitOffset>19</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_pkt_max_byte_cnt_err_irq_rollover</spirit:name>
                     <spirit:bitOffset>18</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_fifo_full_err_irq_rollover</spirit:name>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_pkt_err_irq_rollover</spirit:name>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_pkt_sop_err_irq_rollover</spirit:name>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_wflush_act_irq_rollover</spirit:name>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_drp_pkt_rd_irq_rollover</spirit:name>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_drp_pkt_wr_irq_rollover</spirit:name>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_rflush_act_irq_rollover</spirit:name>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_drp_pkt_irq_rollover</spirit:name>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_inbuff_eop_irq_rollover</spirit:name>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_inbuff_sop_irq_rollover</spirit:name>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_gmii_outbuff_eop_irq_rollover</spirit:name>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_gmii_outbuff_sop_irq_rollover</spirit:name>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_gmii_done_irq_rollover</spirit:name>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_gmii_start_irq_rollover</spirit:name>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_xgmii_outbuff_eop_irq_rollover</spirit:name>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_xgmii_outbuff_sop_irq_rollover</spirit:name>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_xgmii_done_irq_rollover</spirit:name>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_xgmii_start_irq_rollover</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003144</address>
                        <intr.pending>irq0_link_layer_tx</intr.pending>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>raw</spirit:name>
                  <spirit:description>Indicating a rollover for that particular count has occurred</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>mac_pause_frame_irq_rollover</spirit:name>
                     <spirit:bitOffset>28</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mac_out_eop_irq_rollover</spirit:name>
                     <spirit:bitOffset>27</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mac_out_sop_irq_rollover</spirit:name>
                     <spirit:bitOffset>26</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mac_stall_ptp_in_irq_rollover</spirit:name>
                     <spirit:bitOffset>25</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mac_in_eop_irq_rollover</spirit:name>
                     <spirit:bitOffset>24</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mac_in_sop_irq_rollover</spirit:name>
                     <spirit:bitOffset>23</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mac_fsm_count_beyond_ptp_irq_rollover</spirit:name>
                     <spirit:bitOffset>22</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mac_fsm_rollover_irq_rollover</spirit:name>
                     <spirit:bitOffset>21</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_nfifo_dcount_irq_rollover</spirit:name>
                     <spirit:bitOffset>20</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_pfifo_dcount_irq_rollover</spirit:name>
                     <spirit:bitOffset>19</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_pkt_max_byte_cnt_err_irq_rollover</spirit:name>
                     <spirit:bitOffset>18</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_fifo_full_err_irq_rollover</spirit:name>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_pkt_err_irq_rollover</spirit:name>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_pkt_sop_err_irq_rollover</spirit:name>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_wflush_act_irq_rollover</spirit:name>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_drp_pkt_rd_irq_rollover</spirit:name>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_drp_pkt_wr_irq_rollover</spirit:name>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_rflush_act_irq_rollover</spirit:name>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_drp_pkt_irq_rollover</spirit:name>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_inbuff_eop_irq_rollover</spirit:name>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_inbuff_sop_irq_rollover</spirit:name>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_gmii_outbuff_eop_irq_rollover</spirit:name>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_gmii_outbuff_sop_irq_rollover</spirit:name>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_gmii_done_irq_rollover</spirit:name>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_gmii_start_irq_rollover</spirit:name>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_xgmii_outbuff_eop_irq_rollover</spirit:name>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_xgmii_outbuff_sop_irq_rollover</spirit:name>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_xgmii_done_irq_rollover</spirit:name>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs_xgmii_start_irq_rollover</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003148</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x8000313C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : irq0  --> 
         <spirit:vendorExtensions>
               <ids_properties>
                  <module_name>link_layer_tx_regs</module_name>
                  <uvm.package>link_layer_tx_regs_pkg</uvm.package>
                  <reset_type>async</reset_type>
                  <cheader.mask_endianess>little</cheader.mask_endianess>
                  <header.struct_guard>__ASSEMBLER__</header.struct_guard>
                  <explicit_name>true</explicit_name>
                  <vertical_reuse>true</vertical_reuse>
                  <address>0x80003000</address>
               </ids_properties>
            </spirit:vendorExtensions>
         </spirit:addressBlock>     
         <spirit:addressBlock>     
            <spirit:name>link_layer_rx</spirit:name>
            <spirit:description>Link Layer RX Registers
</spirit:description>  <!-- //
                        block : link_layer_rx  --> 
            <spirit:baseAddress>0x80003400</spirit:baseAddress>               
            <spirit:range>0x200</spirit:range>               
            <spirit:width>32</spirit:width>            
            <spirit:register>
               <spirit:name>version</spirit:name>
               <spirit:description>6.1.0: Added registers to disable/enable CRC32 check.
6.2.0: Changed the Interrupt Pending to avoid blocking the register update when enable is 0
6.3.0: Added pending_irq register</spirit:description>
               <spirit:addressOffset>0x0</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00060300</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>major</spirit:name>
                  <spirit:description>Major version</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000110</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>minor</spirit:name>
                  <spirit:description>Minor version</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000011</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>patch</spirit:name>
                  <spirit:description>Patch version</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80003400</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>
  <!-- reg group
                    :mac_client_interface  --> 
          <spirit:registerFile>
               <spirit:name>mac_client_interface</spirit:name>
               <spirit:description>Registers needed for the Clients</spirit:description>
               <spirit:addressOffset>0x4</spirit:addressOffset>
               <spirit:range>0x58</spirit:range>            
               <spirit:register>
                  <spirit:name>version</spirit:name>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00010000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>major</spirit:name>
                     <spirit:description>Major version</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000001</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>minor</spirit:name>
                     <spirit:description>Minor version</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>patch</spirit:name>
                     <spirit:description>Patch version</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003404</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
  <!-- reg group
                    :client_array  --> 
          <spirit:registerFile>
                  <spirit:name>client_array</spirit:name>
                  <spirit:description>Registers needed for the Clients Array</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:range>0x54</spirit:range>            
                  <spirit:register>
                     <spirit:name>client_config</spirit:name>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000002</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>client_flow_ctrl_en</spirit:name>
                        <spirit:description>When set to 1, it enables the flow control feature of that client, whereby the client drdy is monitored in this block before presenting the next cycle of the PTP. When set to 0, it disables the flow control and the PTP traffic is presented without "listening" the drdy from the client.</spirit:description>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>1</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>client_en</spirit:name>
                        <spirit:description>When set to 1, it enables the flow of traffic to the client. When 0, the port is disabled and no traffic is presented to the client.</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003408</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>da_filter_word1</spirit:name>
                     <spirit:description>Destination Address Filter Word1</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x0000DADA</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>da_filter_w1</spirit:name>
                        <spirit:description>This is the MAC Destination address allowed to pass (upper 2 bytes [47:32])</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>1101101011011010</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x8000340C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>da_filter_word0</spirit:name>
                     <spirit:description>Destination Address Filter Word0</spirit:description>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0xDADADADA</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>da_filter_w0</spirit:name>
                        <spirit:description>This is the MAC Destination address allowed to pass (lower 4 bytes [31:0])</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>11011010110110101101101011011010</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003410</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>da_filter_mask_word1</spirit:name>
                     <spirit:description>Destination Address Filter Mask Word1</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>da_filter_mask_w1</spirit:name>
                        <spirit:description>This is the Mask for the MAC Destination address allowed to pass (upper 2 bytes [47:32]). Only the location with a "1" in this mask shall be compared in the Destination Address</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003414</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>da_filter_mask_word0</spirit:name>
                     <spirit:description>Destination Address Filter Mask Word0</spirit:description>
                     <spirit:addressOffset>0x10</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>da_filter_mask_w0</spirit:name>
                        <spirit:description>This is the Mask for the MAC Destination address allowed to pass (lower 4 bytes [31:0]). Only the location with a "1" in this mask shall be compared in the Destination Address</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003418</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>sa_filter_word1</spirit:name>
                     <spirit:description>Source Address Filter Word1</spirit:description>
                     <spirit:addressOffset>0x14</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00005A5A</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>sa_filter_w1</spirit:name>
                        <spirit:description>This is the MAC Source address allowed to pass (upper 2 bytes [47:32])</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0101101001011010</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x8000341C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>sa_filter_word0</spirit:name>
                     <spirit:description>Source Address Filter Word0</spirit:description>
                     <spirit:addressOffset>0x18</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x5A5A5A5A</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>sa_filter_w0</spirit:name>
                        <spirit:description>This is the MAC Source address allowed to pass (lower 4 bytes [31:0])</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>01011010010110100101101001011010</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003420</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>sa_filter_mask_word1</spirit:name>
                     <spirit:description>Source Address Filter Mask Word1</spirit:description>
                     <spirit:addressOffset>0x1C</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>sa_filter_mask_w1</spirit:name>
                        <spirit:description>This is the Mask for the MAC Source address allowed to pass (upper 2 bytes [47:32]). Only the location with a "1" in this mask shall be compared in the Source Address</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003424</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>sa_filter_mask_word0</spirit:name>
                     <spirit:description>Source Address Filter Mask Word0</spirit:description>
                     <spirit:addressOffset>0x20</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>sa_filter_mask_w0</spirit:name>
                        <spirit:description>This is the Mask for the MAC Source address allowed to pass (lower 4 bytes [31:0]). Only the location with a "1" in this mask shall be compared in the Source Address</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003428</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>lt_filter</spirit:name>
                     <spirit:description>Length/Type Filter</spirit:description>
                     <spirit:addressOffset>0x24</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00001717</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>lt_filter</spirit:name>
                        <spirit:description>This is the MAC type allowed to pass</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0001011100010111</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x8000342C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>lt_filter_mask</spirit:name>
                     <spirit:description>Length/Type Filter Mask</spirit:description>
                     <spirit:addressOffset>0x28</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>lt_filter_mask</spirit:name>
                        <spirit:description>This is the Mask for the MAC Type allowed to pass. Only the location with a "1" in this mask shall be compared in the Type field.</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003430</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                     <spirit:name>stats0</spirit:name>
                     <spirit:description>All the Statistic Registers and their configuration.</spirit:description>
                     <spirit:addressOffset>0x2C</spirit:addressOffset>
                     <spirit:range>0x28</spirit:range>            
                     <spirit:register>
                        <spirit:name>rd2clr_config</spirit:name>
                        <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>in_fsm_rollover</spirit:name>
                           <spirit:bitOffset>8</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>one_cycle_pkt</spirit:name>
                           <spirit:bitOffset>7</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>drop_pkt_da</spirit:name>
                           <spirit:bitOffset>6</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>drop_pkt_sa</spirit:name>
                           <spirit:bitOffset>5</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>drop_pkt_lt</spirit:name>
                           <spirit:bitOffset>4</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>drop_pkt_md</spirit:name>
                           <spirit:bitOffset>3</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>filter_fifo_overflow</spirit:name>
                           <spirit:bitOffset>2</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>out_sop</spirit:name>
                           <spirit:bitOffset>1</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>out_eop</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80003434</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>out_eop</spirit:name>
                        <spirit:description>Count of the PTP EOP seen on the output port to client</spirit:description>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>out_eop</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>32</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000000000000000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80003438</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>out_sop</spirit:name>
                        <spirit:description>Count of the PTP SOP seen on the output to client</spirit:description>
                        <spirit:addressOffset>0x8</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>out_sop</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>32</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000000000000000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x8000343C</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>filter_fifo_overflow</spirit:name>
                        <spirit:description>Count of the times the filter FIFO was overflowed</spirit:description>
                        <spirit:addressOffset>0xC</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>filter_fifo_overflow</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80003440</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>drop_pkt_md</spirit:name>
                        <spirit:description>Count of PTP packets dropped due to the MAC Datagram filter</spirit:description>
                        <spirit:addressOffset>0x10</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>drop_pkt_md</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80003444</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>drop_pkt_lt</spirit:name>
                        <spirit:description>Count of PTP packets dropped due to the Length/Type filter</spirit:description>
                        <spirit:addressOffset>0x14</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>drop_pkt_lt</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80003448</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>drop_pkt_sa</spirit:name>
                        <spirit:description>Count of PTP packets dropped due to the Source Address filter</spirit:description>
                        <spirit:addressOffset>0x18</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>drop_pkt_sa</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x8000344C</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>drop_pkt_da</spirit:name>
                        <spirit:description>Count of PTP packets dropped due to the Destination Address filter</spirit:description>
                        <spirit:addressOffset>0x1C</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>drop_pkt_da</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80003450</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>one_cycle_pkt</spirit:name>
                        <spirit:description>Count of PTP packets that are one-cycle</spirit:description>
                        <spirit:addressOffset>0x20</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>one_cycle_pkt</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80003454</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>in_fsm_rollover</spirit:name>
                        <spirit:description>Count of the number of times the input FSM rolled over. This indicates an error in the function of this block</spirit:description>
                        <spirit:addressOffset>0x24</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>in_fsm_rollover</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80003458</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003434</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 
<spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003408</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : client_array  --> 
<spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80003404</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : mac_client_interface  --> 

  <!-- reg group
                    :mac  --> 
          <spirit:registerFile>
               <spirit:name>mac</spirit:name>
               <spirit:addressOffset>0x5C</spirit:addressOffset>
               <spirit:range>0x90</spirit:range>            
               <spirit:register>
                  <spirit:name>version</spirit:name>
                  <spirit:description>2.1.0: Added registers to disable/enable CRC32 check.</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00020100</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>major</spirit:name>
                     <spirit:description>Major version</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000010</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>minor</spirit:name>
                     <spirit:description>Minor version</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000001</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>patch</spirit:name>
                     <spirit:description>Patch version</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000345C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>mac_config</spirit:name>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>inject_crc32_err</spirit:name>
                     <spirit:description>Assert high to ask the logic to insert one crc32 check error when CRC32 logic is implemented.

Write a 1 and HW clears it when completed the action
</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <rtl.hw_clear>true</rtl.hw_clear>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>disable_crc32</spirit:name>
                     <spirit:description>When set to 1, and if the CRC32 logic is implemented, disables checking of correct CRC32.</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>crc32_implmntd</spirit:name>
                     <spirit:description>This is the synthesis parameter value used for CRC32 logic implementation. When 1, it shows the CRC32 logic has been implemented in the logic. Note that, typically CRC32 MUST be implemented in MAC. However, due to some timing issues, we may decide to not have the logic when the system is used in a point-to-point configuration.</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dbg_seq_num_en</spirit:name>
                     <spirit:description>When set to 1 it enables the debug logic to check for consecutive sequence number. 

Typically, this and the corresponding register in the TX path should be configured before any traffic sent between the TX and RX. Otherwise, there will not be synchrony between the sent and expected sequence numbers for at least one time</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>en</spirit:name>
                     <spirit:description>When set to 1 it enables the block. NOTE USED.</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003460</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>da_word1</spirit:name>
                  <spirit:description>Destination Address Word1</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x0000DADA</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>da_w1</spirit:name>
                     <spirit:description>This is the MAC Destination address (upper 2 bytes [47:32])</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1101101011011010</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003464</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>da_word0</spirit:name>
                  <spirit:description>Destination Address Word0</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0xDADADADA</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>da_w0</spirit:name>
                     <spirit:description>This is the MAC Destination address (lower 4 bytes [31:0])</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>32</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>11011010110110101101101011011010</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003468</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
  <!-- reg group
                    :pfifo  --> 
          <spirit:registerFile>
                  <spirit:name>pfifo</spirit:name>
                  <spirit:addressOffset>0x10</spirit:addressOffset>
                  <spirit:range>0x50</spirit:range>            
                  <spirit:register>
                     <spirit:name>version</spirit:name>
                     <spirit:description>Version 1.1.0: Added Icron Attributes for stats script generation</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:reset>
                        <spirit:value>0x00010100</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>major</spirit:name>
                        <spirit:description>Major version</spirit:description>
                        <spirit:bitOffset>16</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000001</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>minor</spirit:name>
                        <spirit:description>Minor version</spirit:description>
                        <spirit:bitOffset>8</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000001</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>patch</spirit:name>
                        <spirit:description>Patch version</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x8000346C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
  <!-- reg group
                    :write_engine  --> 
          <spirit:registerFile>
                     <spirit:name>write_engine</spirit:name>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:range>0x38</spirit:range>
  <!-- reg group
                    :config0  --> 
          <spirit:registerFile>
                        <spirit:name>config0</spirit:name>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:range>0xC</spirit:range>            
                        <spirit:register>
                           <spirit:name>clear</spirit:name>
                           <spirit:description>Synchronous clear for the write clock domain</spirit:description>
                           <spirit:addressOffset>0x0</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>wclr</spirit:name>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <address>0x80003470</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>mode</spirit:name>
                           <spirit:addressOffset>0x4</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000005</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>drp_on_sop</spirit:name>
                              <spirit:description>When set, drops the current packet without writing it to the buffer. See Wiki</spirit:description>
                              <spirit:bitOffset>3</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>drp_on_pkt_err</spirit:name>
                              <spirit:description>When set, removes the packet from the buffer without presenting it to the output interface upon the ERR bit being set before the notification point. See Wiki</spirit:description>
                              <spirit:bitOffset>2</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>1</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>pkt_strm</spirit:name>
                              <spirit:description>Selects packet based or streaming based behavior. See Wiki</spirit:description>
                              <spirit:bitOffset>1</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>flw_ctrl_en</spirit:name>
                              <spirit:description>Enables the flow control. See Wiki</spirit:description>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>1</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <address>0x80003474</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>notify_limit</spirit:name>
                           <spirit:addressOffset>0x8</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>ntfy_lmt</spirit:name>
                              <spirit:description>Sets the number of words required to be written into the packet FIFO before a notification will be generated. See wiki</spirit:description>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>32</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>00000000000000000000000000000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <address>0x80003478</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80003470</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:registerFile>  <!-- end
                of reg group : config0  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                        <spirit:name>stats0</spirit:name>
                        <spirit:description>All the Statistic Registers and their configuration for the Write Engine</spirit:description>
                        <spirit:addressOffset>0xC</spirit:addressOffset>
                        <spirit:range>0x2C</spirit:range>            
                        <spirit:register>
                           <spirit:name>rd2clr_config</spirit:name>
                           <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                           <spirit:addressOffset>0x0</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>flow_ctrl</spirit:name>
                              <spirit:bitOffset>9</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>drp_pkt_wr</spirit:name>
                              <spirit:bitOffset>8</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>drp_pkt_rd</spirit:name>
                              <spirit:bitOffset>7</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>wflush_act</spirit:name>
                              <spirit:bitOffset>6</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>pkt_sop_err</spirit:name>
                              <spirit:bitOffset>5</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>pkt_err</spirit:name>
                              <spirit:bitOffset>4</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>fifo_full_err</spirit:name>
                              <spirit:bitOffset>3</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>pkt_max_byte_cnt_err</spirit:name>
                              <spirit:bitOffset>2</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>pfifo_dcount</spirit:name>
                              <spirit:bitOffset>1</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>nfifo_dcount</spirit:name>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x8000347C</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>nfifo_dcount</spirit:name>
                           <spirit:description>Current level for the notification FIFO in the PFIFO</spirit:description>
                           <spirit:addressOffset>0x4</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>nfifo_dcount</spirit:name>
                              <spirit:description>_icron_water_marker_
_icron_no_counter_</spirit:description>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>16</spirit:bitWidth>
                              <spirit:volatile>true</spirit:volatile>
                              <spirit:access>read-only</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0000000000000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x80003480</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>pfifo_dcount</spirit:name>
                           <spirit:description>Current level for the packet FIFO in the PFIFO</spirit:description>
                           <spirit:addressOffset>0x8</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>pfifo_dcount</spirit:name>
                              <spirit:description>_icron_water_marker_
_icron_no_counter_</spirit:description>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>16</spirit:bitWidth>
                              <spirit:volatile>true</spirit:volatile>
                              <spirit:access>read-only</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0000000000000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x80003484</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>pkt_max_byte_cnt_err</spirit:name>
                           <spirit:description>The count for capped packets in PFIFO write engine, as the result of reaching maximum size in the PFIFO</spirit:description>
                           <spirit:addressOffset>0xC</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>pkt_max_byte_cnt_err</spirit:name>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>8</spirit:bitWidth>
                              <spirit:volatile>true</spirit:volatile>
                              <spirit:access>read-only</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>00000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x80003488</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>fifo_full_err</spirit:name>
                           <spirit:description>The count for either of PFIFO or NFIFO being full</spirit:description>
                           <spirit:addressOffset>0x10</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>fifo_full_err</spirit:name>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>8</spirit:bitWidth>
                              <spirit:volatile>true</spirit:volatile>
                              <spirit:access>read-only</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>00000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x8000348C</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>pkt_err</spirit:name>
                           <spirit:description>The count of packets tagged to be dropped later in the PFIFO read engine</spirit:description>
                           <spirit:addressOffset>0x14</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>pkt_err</spirit:name>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>8</spirit:bitWidth>
                              <spirit:volatile>true</spirit:volatile>
                              <spirit:access>read-only</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>00000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x80003490</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>pkt_sop_err</spirit:name>
                           <spirit:description>The count of packets flushed in the PFIFO during the SOP phase</spirit:description>
                           <spirit:addressOffset>0x18</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>pkt_sop_err</spirit:name>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>8</spirit:bitWidth>
                              <spirit:volatile>true</spirit:volatile>
                              <spirit:access>read-only</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>00000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x80003494</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>wflush_act</spirit:name>
                           <spirit:description>The count of capped packets in the PFIFO. Note that back-to-back packets are counted as one if they are both capped.</spirit:description>
                           <spirit:addressOffset>0x1C</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>wflush_act</spirit:name>
                              <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>8</spirit:bitWidth>
                              <spirit:volatile>true</spirit:volatile>
                              <spirit:access>read-only</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>00000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x80003498</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>drp_pkt_rd</spirit:name>
                           <spirit:description>The count of drop packets flagged to be dropped by the read engine</spirit:description>
                           <spirit:addressOffset>0x20</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>drp_pkt_rd</spirit:name>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>8</spirit:bitWidth>
                              <spirit:volatile>true</spirit:volatile>
                              <spirit:access>read-only</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>00000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x8000349C</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>drp_pkt_wr</spirit:name>
                           <spirit:description>The count of drop packets by the write engine</spirit:description>
                           <spirit:addressOffset>0x24</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>drp_pkt_wr</spirit:name>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>8</spirit:bitWidth>
                              <spirit:volatile>true</spirit:volatile>
                              <spirit:access>read-only</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>00000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x800034A0</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:description>The count of the clock cycles the DRDY is asserted low resulting in flow control</spirit:description>
                           <spirit:addressOffset>0x28</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>flow_ctrl</spirit:name>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>16</spirit:bitWidth>
                              <spirit:volatile>true</spirit:volatile>
                              <spirit:access>read-only</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0000000000000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x800034A4</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x8000347C</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 
<spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003470</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : write_engine  --> 

  <!-- reg group
                    :read_engine  --> 
          <spirit:registerFile>
                     <spirit:name>read_engine</spirit:name>
                     <spirit:addressOffset>0x3C</spirit:addressOffset>
                     <spirit:range>0x14</spirit:range>
  <!-- reg group
                    :config0  --> 
          <spirit:registerFile>
                        <spirit:name>config0</spirit:name>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:range>0x4</spirit:range>            
                        <spirit:register>
                           <spirit:name>clear</spirit:name>
                           <spirit:description>Synchronous clear for the read clock domain</spirit:description>
                           <spirit:addressOffset>0x0</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>rclr</spirit:name>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <address>0x800034A8</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x800034A8</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:registerFile>  <!-- end
                of reg group : config0  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                        <spirit:name>stats0</spirit:name>
                        <spirit:description>All the Statistic Registers and their configuration for the Read Engine</spirit:description>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:range>0x10</spirit:range>            
                        <spirit:register>
                           <spirit:name>rd2clr_config</spirit:name>
                           <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                           <spirit:addressOffset>0x0</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>flow_ctrl</spirit:name>
                              <spirit:bitOffset>2</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>drp_pkt</spirit:name>
                              <spirit:bitOffset>1</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>rflush_act</spirit:name>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x800034AC</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>rflush_act</spirit:name>
                           <spirit:description>The counts of number of packets flushed from the PFIFO.</spirit:description>
                           <spirit:addressOffset>0x4</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>rflush_act</spirit:name>
                              <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>8</spirit:bitWidth>
                              <spirit:volatile>true</spirit:volatile>
                              <spirit:access>read-only</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>00000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x800034B0</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>drp_pkt</spirit:name>
                           <spirit:description>The counts of drop packet in the PFIFO read engine</spirit:description>
                           <spirit:addressOffset>0x8</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>drp_pkt</spirit:name>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>8</spirit:bitWidth>
                              <spirit:volatile>true</spirit:volatile>
                              <spirit:access>read-only</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>00000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x800034B4</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:description>The count of the clock cycles the DRDY is asserted low resulting in flow control</spirit:description>
                           <spirit:addressOffset>0xC</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>flow_ctrl</spirit:name>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>16</spirit:bitWidth>
                              <spirit:volatile>true</spirit:volatile>
                              <spirit:access>read-only</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0000000000000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x800034B8</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x800034AC</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 
<spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x800034A8</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : read_engine  --> 
<spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000346C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : pfifo  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                  <spirit:name>stats0</spirit:name>
                  <spirit:description>All the Statistic Registers and their configuration.</spirit:description>
                  <spirit:addressOffset>0x60</spirit:addressOffset>
                  <spirit:range>0x30</spirit:range>            
                  <spirit:register>
                     <spirit:name>rd2clr_config</spirit:name>
                     <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>dbg_seq_num_in_err</spirit:name>
                        <spirit:bitOffset>10</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>in_fsm_rollover</spirit:name>
                        <spirit:bitOffset>9</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>out_fsm_rollover</spirit:name>
                        <spirit:bitOffset>8</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>crc_err</spirit:name>
                        <spirit:bitOffset>7</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>in_sop</spirit:name>
                        <spirit:bitOffset>6</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>in_eop</spirit:name>
                        <spirit:bitOffset>5</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>inbuff_sop</spirit:name>
                        <spirit:bitOffset>4</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>inbuf_eop</spirit:name>
                        <spirit:bitOffset>3</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>out_sop</spirit:name>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>out_eop</spirit:name>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>pause_frame</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x800034BC</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>pause_frame</spirit:name>
                     <spirit:description>Count of pause frames received</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>pause_frame</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x800034C0</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>out_eop</spirit:name>
                     <spirit:description>Count of the PTP EOP seen on the output port to Client Interface</spirit:description>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>out_eop</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x800034C4</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>out_sop</spirit:name>
                     <spirit:description>Count of the PTP SOP seen on the output port to Client Interface</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>out_sop</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x800034C8</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>inbuf_eop</spirit:name>
                     <spirit:description>Count of the EOP of the PTP packets saved into the input buffer</spirit:description>
                     <spirit:addressOffset>0x10</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>inbuf_eop</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x800034CC</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>inbuf_sop</spirit:name>
                     <spirit:description>Count of the SOP of the PTP packets saved into the input buffer</spirit:description>
                     <spirit:addressOffset>0x14</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>inbuf_sop</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x800034D0</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>in_eop</spirit:name>
                     <spirit:description>Count of the EOP of the PTP packets seen from the RS layer</spirit:description>
                     <spirit:addressOffset>0x18</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>in_eop</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x800034D4</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>in_sop</spirit:name>
                     <spirit:description>Count of the EOP of the PTP packets seen from the RS layer</spirit:description>
                     <spirit:addressOffset>0x1C</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>in_sop</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x800034D8</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>crc_err</spirit:name>
                     <spirit:description>Count of packets with CRC error</spirit:description>
                     <spirit:addressOffset>0x20</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>crc_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x800034DC</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>out_fsm_rollover</spirit:name>
                     <spirit:description>Count of the number of times the output FSM rolled over. This indicates an error in the function of this block</spirit:description>
                     <spirit:addressOffset>0x24</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>out_fsm_rollover</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x800034E0</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>in_fsm_rollover</spirit:name>
                     <spirit:description>Count of the number of times the input FSM rolled over. This indicates an error in the function of this block</spirit:description>
                     <spirit:addressOffset>0x28</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>in_fsm_rollover</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x800034E4</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>dbg_seq_num_in_err</spirit:name>
                     <spirit:description>Count of the number of times the Frame sequence number was in-error during debug mode. See also the dbg_seq_num_en</spirit:description>
                     <spirit:addressOffset>0x2C</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>dbg_seq_num_in_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x800034E8</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800034BC</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 
<spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x8000345C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : mac  --> 

  <!-- reg group
                    :media_rs  --> 
          <spirit:registerFile>
               <spirit:name>media_rs</spirit:name>
               <spirit:description>Registers needed for the Media RS in the RX Path</spirit:description>
               <spirit:addressOffset>0xEC</spirit:addressOffset>
               <spirit:range>0x58</spirit:range>            
               <spirit:register>
                  <spirit:name>version</spirit:name>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00020000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>major</spirit:name>
                     <spirit:description>Major version</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000010</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>minor</spirit:name>
                     <spirit:description>Minor version</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>patch</spirit:name>
                     <spirit:description>Patch version</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800034EC</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>enable</spirit:name>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000001</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>rx_xgmii_en</spirit:name>
                     <spirit:description>When set to 1, and rx_gmii_en is 0, it enables the XGMII path</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_gmii_en</spirit:name>
                     <spirit:description>When set to 1, and rx_xgmii_en is 0, it enables the GMII path</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800034F0</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pa_word1</spirit:name>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00555555</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>pa_word1</spirit:name>
                     <spirit:description>Preamble values (upper 3 bytes)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>24</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>010101010101010101010101</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800034F4</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pa_word0</spirit:name>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x55555555</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>pa_word0</spirit:name>
                     <spirit:description>Preamble values (lower 4 bytes)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>32</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>01010101010101010101010101010101</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800034F8</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>sfd</spirit:name>
                  <spirit:addressOffset>0x10</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x000000D5</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>sfd</spirit:name>
                     <spirit:description>The Start of Frame Delimiter (SFD)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>11010101</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800034FC</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>idle</spirit:name>
                  <spirit:addressOffset>0x14</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x0000001E</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>idle</spirit:name>
                     <spirit:description>Idle character</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00011110</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003500</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                  <spirit:name>stats0</spirit:name>
                  <spirit:description>All the Statistic Registers and their configuration for the GMII</spirit:description>
                  <spirit:addressOffset>0x18</spirit:addressOffset>
                  <spirit:range>0x14</spirit:range>            
                  <spirit:register>
                     <spirit:name>rd2clr_config</spirit:name>
                     <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>gmii_missing_sfd</spirit:name>
                        <spirit:bitOffset>3</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>gmii_data_error</spirit:name>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>gmii_out_sop</spirit:name>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>gmii_out_eop</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003504</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>gmii_out_eop</spirit:name>
                     <spirit:description>Count of the PTP EOP seen on the output port to MAC as the result of traffic on the GMII input port</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>gmii_out_eop</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003508</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>gmii_out_sop</spirit:name>
                     <spirit:description>Count of the PTP SOP seen on the output port to MAC as the result of traffic on the GMII input port</spirit:description>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>gmii_out_sop</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x8000350C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>gmii_data_error</spirit:name>
                     <spirit:description>Count of the GMII data error per IEEE802.3 Section 35.2.2.9</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>gmii_data_error</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003510</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>gmii_missing_sfd</spirit:name>
                     <spirit:description>Count of the GMII data not properly starting with an SFD resulting in dropping the frame per IEEE802.3 Section 35.2.2.7</spirit:description>
                     <spirit:addressOffset>0x10</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>gmii_missing_sfd</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003514</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003504</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 

  <!-- reg group
                    :stats1  --> 
          <spirit:registerFile>
                  <spirit:name>stats1</spirit:name>
                  <spirit:description>All the Statistic Registers and their configuration for the XGMII</spirit:description>
                  <spirit:addressOffset>0x2C</spirit:addressOffset>
                  <spirit:range>0x2C</spirit:range>            
                  <spirit:register>
                     <spirit:name>rd2clr_config</spirit:name>
                     <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>xgmii_runt_frm_detected</spirit:name>
                        <spirit:bitOffset>9</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>xgmii_link_int</spirit:name>
                        <spirit:bitOffset>8</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>xgmii_remote_fault</spirit:name>
                        <spirit:bitOffset>7</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>xgmii_local_fault</spirit:name>
                        <spirit:bitOffset>6</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>xgmii_link_ok</spirit:name>
                        <spirit:bitOffset>5</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>xgmii_wrong_lane_start</spirit:name>
                        <spirit:bitOffset>4</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>xgmii_missing_sfd</spirit:name>
                        <spirit:bitOffset>3</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>xgmii_data_error</spirit:name>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>xgmii_out_sop</spirit:name>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>xgmii_out_eop</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003518</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>xgmii_out_eop</spirit:name>
                     <spirit:description>Count of the PTP EOP seen on the output port to MAC as the result of traffic on the XGMII input port</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>xgmii_out_eop</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x8000351C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>xgmii_out_sop</spirit:name>
                     <spirit:description>Count of the PTP SOP seen on the output port to MAC as the result of traffic on the XGMII input port</spirit:description>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>xgmii_out_sop</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003520</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>xgmii_data_error</spirit:name>
                     <spirit:description>Count of the XGMII data error per IEEE802.3 Sections 46.3.2.3 &amp; 46.3.3.1. The count is the number of "cycles" in which there is an error character and not the number of error bytes</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>xgmii_data_error</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003524</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>xgmii_missing_sfd</spirit:name>
                     <spirit:description>Count of the XGMII data not having the SFD in lane 3 in the next cycle following the cycle where the "start character" appears in lane 0, resulting in dropping the frame per IEEE802.3 Sections 46.3.2.3 &amp; 46.3.3.3</spirit:description>
                     <spirit:addressOffset>0x10</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>xgmii_missing_sfd</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003528</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>xgmii_wrong_lane_start</spirit:name>
                     <spirit:description>Count of the XGMII frame not starting with the "start character" in Lane 0 per IEEE802.3 Sections 46.3.2.3 &amp; 46.3.3.3</spirit:description>
                     <spirit:addressOffset>0x14</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>xgmii_wrong_lane_start</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x8000352C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>xgmii_link_ok</spirit:name>
                     <spirit:description>Count of the XGMII entering in Link OK status per Section 46.3.4 for Link Fault Signaling</spirit:description>
                     <spirit:addressOffset>0x18</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>xgmii_link_ok</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003530</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>xgmii_local_fault</spirit:name>
                     <spirit:description>Count of the XGMII entering in Link Local Fault status per Section 46.3.4 for Link Fault Signaling</spirit:description>
                     <spirit:addressOffset>0x1C</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>xgmii_local_fault</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003534</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>xgmii_remote_fault</spirit:name>
                     <spirit:description>Count of the XGMII entering in Link Remote Fault status per Section 46.3.4 for Link Fault Signaling</spirit:description>
                     <spirit:addressOffset>0x20</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>xgmii_remote_fault</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003538</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>xgmii_link_int</spirit:name>
                     <spirit:description>Count of the XGMII entering in Link Interrupt status per Section 46.3.4 for Link Fault Signaling</spirit:description>
                     <spirit:addressOffset>0x24</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>xgmii_link_int</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x8000353C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>xgmii_runt_frm_detected</spirit:name>
                     <spirit:description>Count of the XGMII runt frames detected. Runt frames are then extended to minimum size Ethernet frames and marked as bad</spirit:description>
                     <spirit:addressOffset>0x28</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>xgmii_runt_frm_detected</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003540</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003518</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : stats1  --> 
<spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x800034EC</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : media_rs  --> 

  <!-- reg group
                    :ptp_guard  --> 
          <spirit:registerFile>
               <spirit:name>ptp_guard</spirit:name>
               <spirit:addressOffset>0x144</spirit:addressOffset>
               <spirit:range>0x2C</spirit:range>            
               <spirit:register>
                  <spirit:name>version</spirit:name>
                  <spirit:description>3.1.0: Fixed bug in Max Cycle Error where in certain mode the cycles were included in the count
3.2.0: Changed the Interrupt Pending to avoid blocking the register update when enable is 0
3.3.0: Added pending_irq register</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00030300</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>major</spirit:name>
                     <spirit:description>Major version</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000011</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>minor</spirit:name>
                     <spirit:description>Minor version</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000011</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>patch</spirit:name>
                     <spirit:description>Patch version</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003544</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
  <!-- reg group
                    :config0  --> 
          <spirit:registerFile>
                  <spirit:name>config0</spirit:name>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:range>0x8</spirit:range>            
                  <spirit:register>
                     <spirit:name>fix_ptp_violations</spirit:name>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000001</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>implemented</spirit:name>
                        <spirit:description>This is the synthesis parameter value used. When 1, it shows the PTP Guard fix logic has been implemented</spirit:description>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>activate</spirit:name>
                        <spirit:description>When 1, and if the fix logic is implemented, it instructs the PTP Guard to fix the PTP violations it detects (and reports). Note that there is a synthesis parameter to generate the "fix" logic or not

When 0, no attempt is done to fix (even if the logic exists) and the PTP Guard will only work as a monitor and reports the violations detected.

For full details of the operation, what violations are detected and fixed, and how the fix is done, see the wiki.</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>1</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003548</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>max_cycles</spirit:name>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00030000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_mode</spirit:name>
                        <spirit:description>This configures the mode of counting towards max_cycles:

0x0: All PTP cycles are included in the count
0x1: PTP cycles with backpressure (drdy=1'b0) are excluded from the count
0x2: PTP cycles with wait (srdy=1'b0) are excluded from the count
0x3: PTP cycles with either backpressure or wait are excluded from the count. Hence, only "absorbed" PTP cycles are included in the count

Other mode values are reserved</spirit:description>
                        <spirit:bitOffset>16</spirit:bitOffset>
                        <spirit:bitWidth>4</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0011</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>max_cycles</spirit:name>
                        <spirit:description>Sets the maximum number of clock cycles the PTP packet can last between its sop and eop taking into account the max_cycle_mode

When set to 0, it instructs the logic not to fix this violation (when the fix logic is available). However, the monitor will still issue a violation when the cycle count reaches its maximum and rollover.</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x8000354C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003548</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : config0  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                  <spirit:name>stats0</spirit:name>
                  <spirit:description>All the Statistic Registers and their configuration</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:range>0x10</spirit:range>            
                  <spirit:register>
                     <spirit:name>rd2clr_config</spirit:name>
                     <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_err</spirit:name>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_eop_err</spirit:name>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_sop_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003550</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>missing_sop_err</spirit:name>
                     <spirit:description>Counts the number of PTP violations due to missing sop where the srdy was asserted without a prior sop assertion</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>missing_sop_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003554</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>missing_eop_err</spirit:name>
                     <spirit:description>Counts the number of PTP violations due to missing eop where the PTP had been started but a new sop is seen without ending the previously started PTP</spirit:description>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>missing_eop_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003558</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>max_cycle_err</spirit:name>
                     <spirit:description>Counts the number of PTP violations due to reaching the maximum allowed cycles after starting a new PTP</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x8000355C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003550</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 

  <!-- reg group
                    :irq0  --> 
          <spirit:registerFile>
                  <spirit:name>irq0</spirit:name>
                  <spirit:description>Define the IRQ group</spirit:description>
                  <spirit:addressOffset>0x1C</spirit:addressOffset>
                  <spirit:range>0x10</spirit:range>            
                  <spirit:register>
                     <spirit:name>enable</spirit:name>
                     <spirit:description>The enable for the actual interrupt signals. Writing a 1 enables the interrupt.
</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_err</spirit:name>
                        <spirit:description>Fires on PTP violations due to reaching the maximum allowed cycles after starting a new PTP</spirit:description>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_eop_err</spirit:name>
                        <spirit:description>Fires on PTP violations due to missing eop where the PTP had been started but a new sop is seen without ending the previously started PTP</spirit:description>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_sop_err</spirit:name>
                        <spirit:description>Fires on PTP violations due to missing sop where the srdy was asserted without a prior sop assertion</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003560</address>
                           <intr.enable>irq666_ptp_guard</intr.enable>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>pending</spirit:name>
                     <spirit:description>The actual interrupt(s) that has triggered. Write a 1 to clear.
</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_err</spirit:name>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_eop_err</spirit:name>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_sop_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003564</address>
                           <intr.status>irq666_ptp_guard</intr.status>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>pending_irq</spirit:name>
                     <spirit:description>Registered version of pending &amp; enable.
</spirit:description>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_err</spirit:name>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_eop_err</spirit:name>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_sop_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003568</address>
                           <intr.pending>irq666_ptp_guard</intr.pending>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>raw</spirit:name>
                     <spirit:description>The status registered values for the interrupt signals, if applicable.</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_err</spirit:name>
                        <spirit:description>Not used</spirit:description>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_eop_err</spirit:name>
                        <spirit:description>Not used</spirit:description>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_sop_err</spirit:name>
                        <spirit:description>Not used</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x8000356C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003560</address>
                        <context>ptp_guard</context>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : irq0  --> 
<spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80003544</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : ptp_guard  --> 

  <!-- reg group
                    :self_test_support  --> 
          <spirit:registerFile>
               <spirit:name>self_test_support</spirit:name>
               <spirit:addressOffset>0x170</spirit:addressOffset>
               <spirit:range>0x1C</spirit:range>            
               <spirit:register>
                  <spirit:name>set_up</spirit:name>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000001</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>enable</spirit:name>
                     <spirit:description>Enables the self-test logic when it is 0x1, provided the proper parameter (p_impl_self_test) is set to "YES". All other traffic to the downstream blocks are inhibited.</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003570</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
  <!-- reg group
                    :media_analyzer  --> 
          <spirit:registerFile>
                  <spirit:name>media_analyzer</spirit:name>
                  <spirit:description>Registers needed for the Media Analyzer needed for self-test</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:range>0x14</spirit:range>            
                  <spirit:register>
                     <spirit:name>version</spirit:name>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:reset>
                        <spirit:value>0x00010000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>major</spirit:name>
                        <spirit:description>Major version</spirit:description>
                        <spirit:bitOffset>16</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000001</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>minor</spirit:name>
                        <spirit:description>Minor version</spirit:description>
                        <spirit:bitOffset>8</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>patch</spirit:name>
                        <spirit:description>Patch version</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003574</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                     <spirit:name>stats0</spirit:name>
                     <spirit:description>All the Statistic Registers and their configuration.</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:range>0x10</spirit:range>            
                     <spirit:register>
                        <spirit:name>rd2clr_config</spirit:name>
                        <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>pkt_count</spirit:name>
                           <spirit:bitOffset>2</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>error_count</spirit:name>
                           <spirit:bitOffset>1</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>lane_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80003578</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>lane_err</spirit:name>
                        <spirit:description>Sticky bit (for each lane) showing an error in the received data of the corresponding lane</spirit:description>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>lane_err</spirit:name>
                           <spirit:description>Flags an error has occurred in a lane. This is a sticky flag. The lane_err[0] refers to Lane 0 (PTP bus [63 -:8]) and lane_err[7] to Lane 7 (PTP bus [08 -:8])</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x8000357C</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>error_count</spirit:name>
                        <spirit:description>Count of the number of errors in each clock cycle.</spirit:description>
                        <spirit:addressOffset>0x8</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>error_count</spirit:name>
                           <spirit:description>Count of the number of errors in each clock cycle. 
**Note** that there could be more than one byte in-error in each clock cycle and this count treats that as one error</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>32</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000000000000000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80003580</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pkt_count</spirit:name>
                        <spirit:description>Count of the number of PTP Packets analyzed.</spirit:description>
                        <spirit:addressOffset>0xC</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>count</spirit:name>
                           <spirit:description>Count of the number of PTP packets processed at the analyzer.
The count is generated when the eop is seen but it does not check if the sop was present</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>32</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000000000000000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80003584</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003578</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 
<spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003574</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : media_analyzer  --> 

  <!-- reg group
                    :de_framer  --> 
          <spirit:registerFile>
                  <spirit:name>de_framer</spirit:name>
                  <spirit:addressOffset>0x18</spirit:addressOffset>
                  <spirit:range>0x4</spirit:range>            
                  <spirit:register>
                     <spirit:name>jumbo_lt_code</spirit:name>
                     <spirit:description>Type code used for Jumbo Frames</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00001717</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>jumbo_lt_code</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0001011100010111</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003588</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003588</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : de_framer  --> 
<spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80003570</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : self_test_support  --> 

  <!-- reg group
                    :irq0  --> 
          <spirit:registerFile>
               <spirit:name>irq0</spirit:name>
               <spirit:description>Define the IRQ group</spirit:description>
               <spirit:addressOffset>0x18C</spirit:addressOffset>
               <spirit:range>0x10</spirit:range>            
               <spirit:register>
                  <spirit:name>enable</spirit:name>
                  <spirit:description>The enable for the actual interrupt signals. Writing a 1 enables the interrupt.
</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>link_int</spirit:name>
                     <spirit:description>Fires when the Link Layer is in Link Interrupt state</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>remote_fault</spirit:name>
                     <spirit:description>Fires when the Link Layer is in Remote Fault state</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>local_fault</spirit:name>
                     <spirit:description>Fires when the Link Layer is in Local Fault state</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>link_ok</spirit:name>
                     <spirit:description>Fires when the Link Layer is in Link OK state</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000358C</address>
                        <intr.enable>irq0_link_layer_rx</intr.enable>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending</spirit:name>
                  <spirit:description>The actual interrupt(s) that has triggered. Write a 1 to clear.
</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>link_int</spirit:name>
                     <spirit:description>Fires when the Link Layer is in Link Interrupt state</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>remote_fault</spirit:name>
                     <spirit:description>Fires when the Link Layer is in Remote Fault state</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>local_fault</spirit:name>
                     <spirit:description>Fires when the Link Layer is in Local Fault state</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>link_ok</spirit:name>
                     <spirit:description>Fires when the Link Layer is in Link OK state</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003590</address>
                        <intr.status>irq0_link_layer_rx</intr.status>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending_irq</spirit:name>
                  <spirit:description>Registered version of pending &amp; enable
</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>link_int</spirit:name>
                     <spirit:description>Fires when the Link Layer is in Link Interrupt state</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>remote_fault</spirit:name>
                     <spirit:description>Fires when the Link Layer is in Remote Fault state</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>local_fault</spirit:name>
                     <spirit:description>Fires when the Link Layer is in Local Fault state</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>link_ok</spirit:name>
                     <spirit:description>Fires when the Link Layer is in Link OK state</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003594</address>
                        <intr.pending>irq0_link_layer_rx</intr.pending>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>raw</spirit:name>
                  <spirit:description>The status registered values for the interrupt signals, if applicable.</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>link_int</spirit:name>
                     <spirit:description>Raw state when the Link Layer is in Link Interrupt state</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>remote_fault</spirit:name>
                     <spirit:description>Raw state when the Link Layer is in Remote Fault state</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>local_fault</spirit:name>
                     <spirit:description>Raw state when the Link Layer is in Local Fault state</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>link_ok</spirit:name>
                     <spirit:description>Raw state when the Link Layer is in Link OK state</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003598</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x8000358C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : irq0  --> 
         <spirit:vendorExtensions>
               <ids_properties>
                  <module_name>link_layer_rx_regs</module_name>
                  <uvm.package>link_layer_rx_regs_pkg</uvm.package>
                  <reset_type>async</reset_type>
                  <cheader.mask_endianess>little</cheader.mask_endianess>
                  <header.struct_guard>__ASSEMBLER__</header.struct_guard>
                  <explicit_name>true</explicit_name>
                  <vertical_reuse>true</vertical_reuse>
                  <address>0x80003400</address>
               </ids_properties>
            </spirit:vendorExtensions>
         </spirit:addressBlock>     
         <spirit:addressBlock>     
            <spirit:name>layer3_tx</spirit:name>
            <spirit:description>Layer 3 Registers
</spirit:description>  <!-- //
                        block : layer3_tx  --> 
            <spirit:baseAddress>0x80003800</spirit:baseAddress>               
            <spirit:range>0x100</spirit:range>               
            <spirit:width>32</spirit:width>            
            <spirit:register>
               <spirit:name>version</spirit:name>
               <spirit:description>4.1.0: Changed the Interrupt Pending to avoid blocking the register update when enable is 0
4.2.0: Added pending_irq register</spirit:description>
               <spirit:addressOffset>0x0</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00040200</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>major</spirit:name>
                  <spirit:description>Major version</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000100</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>minor</spirit:name>
                  <spirit:description>Minor version</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000010</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>patch</spirit:name>
                  <spirit:description>Patch version</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80003800</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>
  <!-- reg group
                    :eth_framer  --> 
          <spirit:registerFile>
               <spirit:name>eth_framer</spirit:name>
               <spirit:addressOffset>0x4</spirit:addressOffset>
               <spirit:range>0xB4</spirit:range>            
               <spirit:register>
                  <spirit:name>version</spirit:name>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00030000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>major</spirit:name>
                     <spirit:description>Major version</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000011</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>minor</spirit:name>
                     <spirit:description>Minor version</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>patch</spirit:name>
                     <spirit:description>Patch version</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003804</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
  <!-- reg group
                    :config0  --> 
          <spirit:registerFile>
                  <spirit:name>config0</spirit:name>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:range>0x14</spirit:range>            
                  <spirit:register>
                     <spirit:name>max_byte</spirit:name>
                     <spirit:description>Maximum bytes in incoming PTP bytes</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000080</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_byte</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>14</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000010000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003808</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>mac_dg_type</spirit:name>
                     <spirit:description>MAC Datagram Type used in the out PTP</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000004</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>mac_dg_type</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000100</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x8000380C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>timer_wait</spirit:name>
                     <spirit:description>Maximum number of clock cycles that is allowed to hold a new incoming PTP before it is put into a MAC Datagram if the input PTPs are not back-to-back and the downstream is not busy. The timer starts when a new PTP is received. This timer gives a control of aggregating input PTPs that are gapped.

Note: A value of 0x0 instructs the logic to not wait for input PTPs if they are gapped, unless the downstream is busy in which case the logic will always wait for gapped input PTPs unless the next PTP has the "potential" to go over the MTU size</spirit:description>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>timer_wait</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>12</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003810</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>mtu_size</spirit:name>
                     <spirit:description>This is the MTU size to use. 

Note that the FPGA build must have been built with the highest of normal MTU=1500 or Jumbo MTU=9000 (see max_mtu_size). Accordingly, this value should be less than that.</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x000005DC</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>mtu_size</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>14</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00010111011100</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003814</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>max_mtu_size</spirit:name>
                     <spirit:description>This is the MTU size used during the FPGA build.</spirit:description>
                     <spirit:addressOffset>0x10</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x000005DC</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_mtu_size</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>14</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00010111011100</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003818</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003808</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : config0  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                  <spirit:name>stats0</spirit:name>
                  <spirit:description>All the Statistic Registers and their configuration.</spirit:description>
                  <spirit:addressOffset>0x18</spirit:addressOffset>
                  <spirit:range>0x20</spirit:range>            
                  <spirit:register>
                     <spirit:name>rd2clr_config</spirit:name>
                     <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>mac_dg_size_err</spirit:name>
                        <spirit:bitOffset>6</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>in_sop</spirit:name>
                        <spirit:bitOffset>5</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>in_eop</spirit:name>
                        <spirit:bitOffset>4</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>inbuff_sop</spirit:name>
                        <spirit:bitOffset>3</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>inbuff_eop</spirit:name>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>out_sop</spirit:name>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>out_eop</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x8000381C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>out_eop</spirit:name>
                     <spirit:description>Count of the PTP EOP seen on the output port</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>out_eop</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003820</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>out_sop</spirit:name>
                     <spirit:description>Count of the PTP SOP seen on the output port</spirit:description>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>out_sop</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003824</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>inbuff_eop</spirit:name>
                     <spirit:description>Count of the EOP of the PTP packets seen at the buffer</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>inbuff_eop</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003828</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>inbuff_sop</spirit:name>
                     <spirit:description>Count of the EOP of the PTP packets seen at the buffer</spirit:description>
                     <spirit:addressOffset>0x10</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>inbuff_sop</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x8000382C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>in_eop</spirit:name>
                     <spirit:description>Count of the EOP of the PTP packets on the input port</spirit:description>
                     <spirit:addressOffset>0x14</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>in_eop</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003830</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>in_sop</spirit:name>
                     <spirit:description>Count of the EOP of the PTP packets on the input port</spirit:description>
                     <spirit:addressOffset>0x18</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>in_sop</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003834</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>mac_dg_size_err</spirit:name>
                     <spirit:description>Count of the MAC DataGram Size Calculation Error. This does not role over when reached its maximum</spirit:description>
                     <spirit:addressOffset>0x1C</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>mac_dg_size_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003838</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000381C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 

  <!-- reg group
                    :pfifo  --> 
          <spirit:registerFile>
                  <spirit:name>pfifo</spirit:name>
                  <spirit:addressOffset>0x38</spirit:addressOffset>
                  <spirit:range>0x50</spirit:range>            
                  <spirit:register>
                     <spirit:name>version</spirit:name>
                     <spirit:description>Version 1.1.0: Added Icron Attributes for stats script generation</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:reset>
                        <spirit:value>0x00010100</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>major</spirit:name>
                        <spirit:description>Major version</spirit:description>
                        <spirit:bitOffset>16</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000001</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>minor</spirit:name>
                        <spirit:description>Minor version</spirit:description>
                        <spirit:bitOffset>8</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000001</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>patch</spirit:name>
                        <spirit:description>Patch version</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x8000383C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
  <!-- reg group
                    :write_engine  --> 
          <spirit:registerFile>
                     <spirit:name>write_engine</spirit:name>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:range>0x38</spirit:range>
  <!-- reg group
                    :config0  --> 
          <spirit:registerFile>
                        <spirit:name>config0</spirit:name>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:range>0xC</spirit:range>            
                        <spirit:register>
                           <spirit:name>clear</spirit:name>
                           <spirit:description>Synchronous clear for the write clock domain</spirit:description>
                           <spirit:addressOffset>0x0</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>wclr</spirit:name>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <address>0x80003840</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>mode</spirit:name>
                           <spirit:addressOffset>0x4</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000005</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>drp_on_sop</spirit:name>
                              <spirit:description>When set, drops the current packet without writing it to the buffer. See Wiki</spirit:description>
                              <spirit:bitOffset>3</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>drp_on_pkt_err</spirit:name>
                              <spirit:description>When set, removes the packet from the buffer without presenting it to the output interface upon the ERR bit being set before the notification point. See Wiki</spirit:description>
                              <spirit:bitOffset>2</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>1</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>pkt_strm</spirit:name>
                              <spirit:description>Selects packet based or streaming based behavior. See Wiki</spirit:description>
                              <spirit:bitOffset>1</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>flw_ctrl_en</spirit:name>
                              <spirit:description>Enables the flow control. See Wiki</spirit:description>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>1</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <address>0x80003844</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>notify_limit</spirit:name>
                           <spirit:addressOffset>0x8</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>ntfy_lmt</spirit:name>
                              <spirit:description>Sets the number of words required to be written into the packet FIFO before a notification will be generated. See wiki</spirit:description>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>32</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>00000000000000000000000000000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <address>0x80003848</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80003840</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:registerFile>  <!-- end
                of reg group : config0  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                        <spirit:name>stats0</spirit:name>
                        <spirit:description>All the Statistic Registers and their configuration for the Write Engine</spirit:description>
                        <spirit:addressOffset>0xC</spirit:addressOffset>
                        <spirit:range>0x2C</spirit:range>            
                        <spirit:register>
                           <spirit:name>rd2clr_config</spirit:name>
                           <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                           <spirit:addressOffset>0x0</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>flow_ctrl</spirit:name>
                              <spirit:bitOffset>9</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>drp_pkt_wr</spirit:name>
                              <spirit:bitOffset>8</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>drp_pkt_rd</spirit:name>
                              <spirit:bitOffset>7</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>wflush_act</spirit:name>
                              <spirit:bitOffset>6</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>pkt_sop_err</spirit:name>
                              <spirit:bitOffset>5</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>pkt_err</spirit:name>
                              <spirit:bitOffset>4</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>fifo_full_err</spirit:name>
                              <spirit:bitOffset>3</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>pkt_max_byte_cnt_err</spirit:name>
                              <spirit:bitOffset>2</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>pfifo_dcount</spirit:name>
                              <spirit:bitOffset>1</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>nfifo_dcount</spirit:name>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x8000384C</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>nfifo_dcount</spirit:name>
                           <spirit:description>Current level for the notification FIFO in the PFIFO</spirit:description>
                           <spirit:addressOffset>0x4</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>nfifo_dcount</spirit:name>
                              <spirit:description>_icron_water_marker_
_icron_no_counter_</spirit:description>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>16</spirit:bitWidth>
                              <spirit:volatile>true</spirit:volatile>
                              <spirit:access>read-only</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0000000000000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x80003850</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>pfifo_dcount</spirit:name>
                           <spirit:description>Current level for the packet FIFO in the PFIFO</spirit:description>
                           <spirit:addressOffset>0x8</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>pfifo_dcount</spirit:name>
                              <spirit:description>_icron_water_marker_
_icron_no_counter_</spirit:description>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>16</spirit:bitWidth>
                              <spirit:volatile>true</spirit:volatile>
                              <spirit:access>read-only</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0000000000000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x80003854</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>pkt_max_byte_cnt_err</spirit:name>
                           <spirit:description>The count for capped packets in PFIFO write engine, as the result of reaching maximum size in the PFIFO</spirit:description>
                           <spirit:addressOffset>0xC</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>pkt_max_byte_cnt_err</spirit:name>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>8</spirit:bitWidth>
                              <spirit:volatile>true</spirit:volatile>
                              <spirit:access>read-only</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>00000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x80003858</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>fifo_full_err</spirit:name>
                           <spirit:description>The count for either of PFIFO or NFIFO being full</spirit:description>
                           <spirit:addressOffset>0x10</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>fifo_full_err</spirit:name>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>8</spirit:bitWidth>
                              <spirit:volatile>true</spirit:volatile>
                              <spirit:access>read-only</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>00000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x8000385C</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>pkt_err</spirit:name>
                           <spirit:description>The count of packets tagged to be dropped later in the PFIFO read engine</spirit:description>
                           <spirit:addressOffset>0x14</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>pkt_err</spirit:name>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>8</spirit:bitWidth>
                              <spirit:volatile>true</spirit:volatile>
                              <spirit:access>read-only</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>00000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x80003860</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>pkt_sop_err</spirit:name>
                           <spirit:description>The count of packets flushed in the PFIFO during the SOP phase</spirit:description>
                           <spirit:addressOffset>0x18</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>pkt_sop_err</spirit:name>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>8</spirit:bitWidth>
                              <spirit:volatile>true</spirit:volatile>
                              <spirit:access>read-only</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>00000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x80003864</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>wflush_act</spirit:name>
                           <spirit:description>The count of capped packets in the PFIFO. Note that back-to-back packets are counted as one if they are both capped.</spirit:description>
                           <spirit:addressOffset>0x1C</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>wflush_act</spirit:name>
                              <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>8</spirit:bitWidth>
                              <spirit:volatile>true</spirit:volatile>
                              <spirit:access>read-only</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>00000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x80003868</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>drp_pkt_rd</spirit:name>
                           <spirit:description>The count of drop packets flagged to be dropped by the read engine</spirit:description>
                           <spirit:addressOffset>0x20</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>drp_pkt_rd</spirit:name>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>8</spirit:bitWidth>
                              <spirit:volatile>true</spirit:volatile>
                              <spirit:access>read-only</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>00000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x8000386C</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>drp_pkt_wr</spirit:name>
                           <spirit:description>The count of drop packets by the write engine</spirit:description>
                           <spirit:addressOffset>0x24</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>drp_pkt_wr</spirit:name>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>8</spirit:bitWidth>
                              <spirit:volatile>true</spirit:volatile>
                              <spirit:access>read-only</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>00000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x80003870</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:description>The count of the clock cycles the DRDY is asserted low resulting in flow control</spirit:description>
                           <spirit:addressOffset>0x28</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>flow_ctrl</spirit:name>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>16</spirit:bitWidth>
                              <spirit:volatile>true</spirit:volatile>
                              <spirit:access>read-only</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0000000000000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x80003874</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x8000384C</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 
<spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003840</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : write_engine  --> 

  <!-- reg group
                    :read_engine  --> 
          <spirit:registerFile>
                     <spirit:name>read_engine</spirit:name>
                     <spirit:addressOffset>0x3C</spirit:addressOffset>
                     <spirit:range>0x14</spirit:range>
  <!-- reg group
                    :config0  --> 
          <spirit:registerFile>
                        <spirit:name>config0</spirit:name>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:range>0x4</spirit:range>            
                        <spirit:register>
                           <spirit:name>clear</spirit:name>
                           <spirit:description>Synchronous clear for the read clock domain</spirit:description>
                           <spirit:addressOffset>0x0</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>rclr</spirit:name>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <address>0x80003878</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80003878</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:registerFile>  <!-- end
                of reg group : config0  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                        <spirit:name>stats0</spirit:name>
                        <spirit:description>All the Statistic Registers and their configuration for the Read Engine</spirit:description>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:range>0x10</spirit:range>            
                        <spirit:register>
                           <spirit:name>rd2clr_config</spirit:name>
                           <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                           <spirit:addressOffset>0x0</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>flow_ctrl</spirit:name>
                              <spirit:bitOffset>2</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>drp_pkt</spirit:name>
                              <spirit:bitOffset>1</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>rflush_act</spirit:name>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x8000387C</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>rflush_act</spirit:name>
                           <spirit:description>The counts of number of packets flushed from the PFIFO.</spirit:description>
                           <spirit:addressOffset>0x4</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>rflush_act</spirit:name>
                              <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>8</spirit:bitWidth>
                              <spirit:volatile>true</spirit:volatile>
                              <spirit:access>read-only</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>00000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x80003880</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>drp_pkt</spirit:name>
                           <spirit:description>The counts of drop packet in the PFIFO read engine</spirit:description>
                           <spirit:addressOffset>0x8</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>drp_pkt</spirit:name>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>8</spirit:bitWidth>
                              <spirit:volatile>true</spirit:volatile>
                              <spirit:access>read-only</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>00000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x80003884</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:description>The count of the clock cycles the DRDY is asserted low resulting in flow control</spirit:description>
                           <spirit:addressOffset>0xC</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>flow_ctrl</spirit:name>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>16</spirit:bitWidth>
                              <spirit:volatile>true</spirit:volatile>
                              <spirit:access>read-only</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0000000000000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x80003888</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x8000387C</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 
<spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003878</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : read_engine  --> 
<spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000383C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : pfifo  --> 

  <!-- reg group
                    :ptp_guard  --> 
          <spirit:registerFile>
                  <spirit:name>ptp_guard</spirit:name>
                  <spirit:addressOffset>0x88</spirit:addressOffset>
                  <spirit:range>0x2C</spirit:range>            
                  <spirit:register>
                     <spirit:name>version</spirit:name>
                     <spirit:description>3.1.0: Fixed bug in Max Cycle Error where in certain mode the cycles were included in the count
3.2.0: Changed the Interrupt Pending to avoid blocking the register update when enable is 0
3.3.0: Added pending_irq register</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:reset>
                        <spirit:value>0x00030300</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>major</spirit:name>
                        <spirit:description>Major version</spirit:description>
                        <spirit:bitOffset>16</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000011</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>minor</spirit:name>
                        <spirit:description>Minor version</spirit:description>
                        <spirit:bitOffset>8</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000011</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>patch</spirit:name>
                        <spirit:description>Patch version</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x8000388C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
  <!-- reg group
                    :config0  --> 
          <spirit:registerFile>
                     <spirit:name>config0</spirit:name>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:range>0x8</spirit:range>            
                     <spirit:register>
                        <spirit:name>fix_ptp_violations</spirit:name>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000001</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>implemented</spirit:name>
                           <spirit:description>This is the synthesis parameter value used. When 1, it shows the PTP Guard fix logic has been implemented</spirit:description>
                           <spirit:bitOffset>1</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>activate</spirit:name>
                           <spirit:description>When 1, and if the fix logic is implemented, it instructs the PTP Guard to fix the PTP violations it detects (and reports). Note that there is a synthesis parameter to generate the "fix" logic or not

When 0, no attempt is done to fix (even if the logic exists) and the PTP Guard will only work as a monitor and reports the violations detected.

For full details of the operation, what violations are detected and fixed, and how the fix is done, see the wiki.</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>1</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80003890</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>max_cycles</spirit:name>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00030000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>max_cycle_mode</spirit:name>
                           <spirit:description>This configures the mode of counting towards max_cycles:

0x0: All PTP cycles are included in the count
0x1: PTP cycles with backpressure (drdy=1'b0) are excluded from the count
0x2: PTP cycles with wait (srdy=1'b0) are excluded from the count
0x3: PTP cycles with either backpressure or wait are excluded from the count. Hence, only "absorbed" PTP cycles are included in the count

Other mode values are reserved</spirit:description>
                           <spirit:bitOffset>16</spirit:bitOffset>
                           <spirit:bitWidth>4</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0011</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>max_cycles</spirit:name>
                           <spirit:description>Sets the maximum number of clock cycles the PTP packet can last between its sop and eop taking into account the max_cycle_mode

When set to 0, it instructs the logic not to fix this violation (when the fix logic is available). However, the monitor will still issue a violation when the cycle count reaches its maximum and rollover.</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80003894</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003890</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : config0  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                     <spirit:name>stats0</spirit:name>
                     <spirit:description>All the Statistic Registers and their configuration</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:range>0x10</spirit:range>            
                     <spirit:register>
                        <spirit:name>rd2clr_config</spirit:name>
                        <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>max_cycle_err</spirit:name>
                           <spirit:bitOffset>2</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>missing_eop_err</spirit:name>
                           <spirit:bitOffset>1</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>missing_sop_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80003898</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>missing_sop_err</spirit:name>
                        <spirit:description>Counts the number of PTP violations due to missing sop where the srdy was asserted without a prior sop assertion</spirit:description>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>missing_sop_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x8000389C</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>missing_eop_err</spirit:name>
                        <spirit:description>Counts the number of PTP violations due to missing eop where the PTP had been started but a new sop is seen without ending the previously started PTP</spirit:description>
                        <spirit:addressOffset>0x8</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>missing_eop_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x800038A0</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>max_cycle_err</spirit:name>
                        <spirit:description>Counts the number of PTP violations due to reaching the maximum allowed cycles after starting a new PTP</spirit:description>
                        <spirit:addressOffset>0xC</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>max_cycle_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x800038A4</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003898</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 

  <!-- reg group
                    :irq0  --> 
          <spirit:registerFile>
                     <spirit:name>irq0</spirit:name>
                     <spirit:description>Define the IRQ group</spirit:description>
                     <spirit:addressOffset>0x1C</spirit:addressOffset>
                     <spirit:range>0x10</spirit:range>            
                     <spirit:register>
                        <spirit:name>enable</spirit:name>
                        <spirit:description>The enable for the actual interrupt signals. Writing a 1 enables the interrupt.
</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>max_cycle_err</spirit:name>
                           <spirit:description>Fires on PTP violations due to reaching the maximum allowed cycles after starting a new PTP</spirit:description>
                           <spirit:bitOffset>2</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>missing_eop_err</spirit:name>
                           <spirit:description>Fires on PTP violations due to missing eop where the PTP had been started but a new sop is seen without ending the previously started PTP</spirit:description>
                           <spirit:bitOffset>1</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>missing_sop_err</spirit:name>
                           <spirit:description>Fires on PTP violations due to missing sop where the srdy was asserted without a prior sop assertion</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x800038A8</address>
                              <intr.enable>irq666_ptp_guard</intr.enable>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pending</spirit:name>
                        <spirit:description>The actual interrupt(s) that has triggered. Write a 1 to clear.
</spirit:description>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>max_cycle_err</spirit:name>
                           <spirit:bitOffset>2</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>missing_eop_err</spirit:name>
                           <spirit:bitOffset>1</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>missing_sop_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x800038AC</address>
                              <intr.status>irq666_ptp_guard</intr.status>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pending_irq</spirit:name>
                        <spirit:description>Registered version of pending &amp; enable.
</spirit:description>
                        <spirit:addressOffset>0x8</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>max_cycle_err</spirit:name>
                           <spirit:bitOffset>2</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>missing_eop_err</spirit:name>
                           <spirit:bitOffset>1</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>missing_sop_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x800038B0</address>
                              <intr.pending>irq666_ptp_guard</intr.pending>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>raw</spirit:name>
                        <spirit:description>The status registered values for the interrupt signals, if applicable.</spirit:description>
                        <spirit:addressOffset>0xC</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>max_cycle_err</spirit:name>
                           <spirit:description>Not used</spirit:description>
                           <spirit:bitOffset>2</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>missing_eop_err</spirit:name>
                           <spirit:description>Not used</spirit:description>
                           <spirit:bitOffset>1</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>missing_sop_err</spirit:name>
                           <spirit:description>Not used</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x800038B4</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x800038A8</address>
                           <context>ptp_guard</context>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : irq0  --> 
<spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000388C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : ptp_guard  --> 
<spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80003804</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : eth_framer  --> 

  <!-- reg group
                    :irq0  --> 
          <spirit:registerFile>
               <spirit:name>irq0</spirit:name>
               <spirit:description>Define the IRQ group</spirit:description>
               <spirit:addressOffset>0xB8</spirit:addressOffset>
               <spirit:range>0x10</spirit:range>            
               <spirit:register>
                  <spirit:name>enable</spirit:name>
                  <spirit:description>Indicating a rollover for that particular count has occurred
</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>framer_stats0_out_eop_irq_rollover</spirit:name>
                     <spirit:bitOffset>18</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_stats0_out_sop_irq_rollover</spirit:name>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_stats0_inbuff_eop_irq_rollover</spirit:name>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_stats0_inbuff_sop_irq_rollover</spirit:name>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_stats0_in_eop_irq_rollover</spirit:name>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_stats0_in_sop_irq_rollover</spirit:name>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_write_engine_stats0_nfifo_dcount_irq_rollover</spirit:name>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_write_engine_stats0_pfifo_dcount_irq_rollover</spirit:name>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_write_engine_stats0_pkt_max_byte_cnt_err_irq_rollover</spirit:name>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_write_engine_stats0_fifo_full_err_irq_rollover</spirit:name>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_write_engine_stats0_pkt_err_irq_rollover</spirit:name>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_write_engine_stats0_pkt_sop_err_irq_rollover</spirit:name>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_write_engine_stats0_wflush_act_irq_rollover</spirit:name>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_write_engine_stats0_drp_pkt_rd_irq_rollover</spirit:name>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_write_engine_stats0_drp_pkt_wr_irq_rollover</spirit:name>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_write_engine_stats0_flow_ctrl_irq_rollover</spirit:name>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_read_engine_stats0_rflush_act_irq_rollover</spirit:name>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_read_engine_stats0_drp_pkt_irq_rollover</spirit:name>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_read_engine_stats0_flow_ctrl_irq_rollover</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800038B8</address>
                        <intr.enable>irq1_layer3_tx</intr.enable>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending</spirit:name>
                  <spirit:description>Indicating a rollover for that particular count has occurred
</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>framer_stats0_out_eop_irq_rollover</spirit:name>
                     <spirit:bitOffset>18</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_stats0_out_sop_irq_rollover</spirit:name>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_stats0_inbuff_eop_irq_rollover</spirit:name>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_stats0_inbuff_sop_irq_rollover</spirit:name>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_stats0_in_eop_irq_rollover</spirit:name>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_stats0_in_sop_irq_rollover</spirit:name>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_write_engine_stats0_nfifo_dcount_irq_rollover</spirit:name>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_write_engine_stats0_pfifo_dcount_irq_rollover</spirit:name>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_write_engine_stats0_pkt_max_byte_cnt_err_irq_rollover</spirit:name>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_write_engine_stats0_fifo_full_err_irq_rollover</spirit:name>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_write_engine_stats0_pkt_err_irq_rollover</spirit:name>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_write_engine_stats0_pkt_sop_err_irq_rollover</spirit:name>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_write_engine_stats0_wflush_act_irq_rollover</spirit:name>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_write_engine_stats0_drp_pkt_rd_irq_rollover</spirit:name>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_write_engine_stats0_drp_pkt_wr_irq_rollover</spirit:name>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_write_engine_stats0_flow_ctrl_irq_rollover</spirit:name>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_read_engine_stats0_rflush_act_irq_rollover</spirit:name>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_read_engine_stats0_drp_pkt_irq_rollover</spirit:name>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_read_engine_stats0_flow_ctrl_irq_rollover</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800038BC</address>
                        <intr.status>irq1_layer3_tx</intr.status>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending_irq</spirit:name>
                  <spirit:description>Registered version of pending &amp; enable
</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>framer_stats0_out_eop_irq_rollover</spirit:name>
                     <spirit:bitOffset>18</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_stats0_out_sop_irq_rollover</spirit:name>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_stats0_inbuff_eop_irq_rollover</spirit:name>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_stats0_inbuff_sop_irq_rollover</spirit:name>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_stats0_in_eop_irq_rollover</spirit:name>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_stats0_in_sop_irq_rollover</spirit:name>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_write_engine_stats0_nfifo_dcount_irq_rollover</spirit:name>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_write_engine_stats0_pfifo_dcount_irq_rollover</spirit:name>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_write_engine_stats0_pkt_max_byte_cnt_err_irq_rollover</spirit:name>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_write_engine_stats0_fifo_full_err_irq_rollover</spirit:name>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_write_engine_stats0_pkt_err_irq_rollover</spirit:name>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_write_engine_stats0_pkt_sop_err_irq_rollover</spirit:name>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_write_engine_stats0_wflush_act_irq_rollover</spirit:name>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_write_engine_stats0_drp_pkt_rd_irq_rollover</spirit:name>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_write_engine_stats0_drp_pkt_wr_irq_rollover</spirit:name>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_write_engine_stats0_flow_ctrl_irq_rollover</spirit:name>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_read_engine_stats0_rflush_act_irq_rollover</spirit:name>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_read_engine_stats0_drp_pkt_irq_rollover</spirit:name>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_read_engine_stats0_flow_ctrl_irq_rollover</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800038C0</address>
                        <intr.pending>irq1_layer3_tx</intr.pending>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>raw</spirit:name>
                  <spirit:description>Indicating a rollover for that particular count has occurred</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>framer_stats0_out_eop_irq_rollover</spirit:name>
                     <spirit:bitOffset>18</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_stats0_out_sop_irq_rollover</spirit:name>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_stats0_inbuff_eop_irq_rollover</spirit:name>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_stats0_inbuff_sop_irq_rollover</spirit:name>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_stats0_in_eop_irq_rollover</spirit:name>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_stats0_in_sop_irq_rollover</spirit:name>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_write_engine_stats0_nfifo_dcount_irq_rollover</spirit:name>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_write_engine_stats0_pfifo_dcount_irq_rollover</spirit:name>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_write_engine_stats0_pkt_max_byte_cnt_err_irq_rollover</spirit:name>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_write_engine_stats0_fifo_full_err_irq_rollover</spirit:name>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_write_engine_stats0_pkt_err_irq_rollover</spirit:name>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_write_engine_stats0_pkt_sop_err_irq_rollover</spirit:name>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_write_engine_stats0_wflush_act_irq_rollover</spirit:name>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_write_engine_stats0_drp_pkt_rd_irq_rollover</spirit:name>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_write_engine_stats0_drp_pkt_wr_irq_rollover</spirit:name>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_write_engine_stats0_flow_ctrl_irq_rollover</spirit:name>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_read_engine_stats0_rflush_act_irq_rollover</spirit:name>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_read_engine_stats0_drp_pkt_irq_rollover</spirit:name>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>framer_pfifo_read_engine_stats0_flow_ctrl_irq_rollover</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800038C4</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x800038B8</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : irq0  --> 
         <spirit:vendorExtensions>
               <ids_properties>
                  <module_name>layer3_tx_regs</module_name>
                  <uvm.package>layer3_tx_regs_pkg</uvm.package>
                  <reset_type>async</reset_type>
                  <cheader.mask_endianess>little</cheader.mask_endianess>
                  <header.struct_guard>__ASSEMBLER__</header.struct_guard>
                  <explicit_name>true</explicit_name>
                  <vertical_reuse>true</vertical_reuse>
                  <address>0x80003800</address>
               </ids_properties>
            </spirit:vendorExtensions>
         </spirit:addressBlock>     
         <spirit:addressBlock>     
            <spirit:name>layer3_rx</spirit:name>
            <spirit:description>Layer 3 Registers
</spirit:description>  <!-- //
                        block : layer3_rx  --> 
            <spirit:baseAddress>0x80003C00</spirit:baseAddress>               
            <spirit:range>0x100</spirit:range>               
            <spirit:width>32</spirit:width>            
            <spirit:register>
               <spirit:name>version</spirit:name>
               <spirit:description>3.1.0: Changed the Interrupt Pending to avoid blocking the register update when enable is 0
3.2.0: Added pending_irq register</spirit:description>
               <spirit:addressOffset>0x0</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00030200</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>major</spirit:name>
                  <spirit:description>Major version</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000011</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>minor</spirit:name>
                  <spirit:description>Minor version</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000010</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>patch</spirit:name>
                  <spirit:description>Patch version</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80003C00</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>
  <!-- reg group
                    :eth_de_framer  --> 
          <spirit:registerFile>
               <spirit:name>eth_de_framer</spirit:name>
               <spirit:addressOffset>0x4</spirit:addressOffset>
               <spirit:range>0x18</spirit:range>            
               <spirit:register>
                  <spirit:name>version</spirit:name>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00010000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>major</spirit:name>
                     <spirit:description>Major version</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000001</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>minor</spirit:name>
                     <spirit:description>Minor version</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>patch</spirit:name>
                     <spirit:description>Patch version</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003C04</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
  <!-- reg group
                    :config0  --> 
          <spirit:registerFile>
                  <spirit:name>config0</spirit:name>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:range>0x4</spirit:range>            
                  <spirit:register>
                     <spirit:name>jumbo_lt_code</spirit:name>
                     <spirit:description>Type code used for Jumbo Frames</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00001717</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>jumbo_lt_code</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0001011100010111</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003C08</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003C08</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : config0  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                  <spirit:name>stats0</spirit:name>
                  <spirit:description>All the Statistic Registers and their configuration.</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:range>0x10</spirit:range>            
                  <spirit:register>
                     <spirit:name>rd2clr_config</spirit:name>
                     <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>non_eth_pkt</spirit:name>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>out_sop</spirit:name>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>out_eop</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003C0C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>out_eop</spirit:name>
                     <spirit:description>Count of the PTP EOP seen on the output port</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>out_eop</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003C10</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>out_sop</spirit:name>
                     <spirit:description>Count of the PTP SOP seen on the output port</spirit:description>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>out_sop</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003C14</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>non_eth_pkt</spirit:name>
                     <spirit:description>Count of the Eth packets that the type is not supported</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>non_eth_pkt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003C18</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003C0C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 
<spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80003C04</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : eth_de_framer  --> 

  <!-- reg group
                    :ptp_guard  --> 
          <spirit:registerFile>
               <spirit:name>ptp_guard</spirit:name>
               <spirit:addressOffset>0x1C</spirit:addressOffset>
               <spirit:range>0x2C</spirit:range>            
               <spirit:register>
                  <spirit:name>version</spirit:name>
                  <spirit:description>3.1.0: Fixed bug in Max Cycle Error where in certain mode the cycles were included in the count
3.2.0: Changed the Interrupt Pending to avoid blocking the register update when enable is 0
3.3.0: Added pending_irq register</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00030300</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>major</spirit:name>
                     <spirit:description>Major version</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000011</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>minor</spirit:name>
                     <spirit:description>Minor version</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000011</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>patch</spirit:name>
                     <spirit:description>Patch version</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003C1C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
  <!-- reg group
                    :config0  --> 
          <spirit:registerFile>
                  <spirit:name>config0</spirit:name>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:range>0x8</spirit:range>            
                  <spirit:register>
                     <spirit:name>fix_ptp_violations</spirit:name>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000001</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>implemented</spirit:name>
                        <spirit:description>This is the synthesis parameter value used. When 1, it shows the PTP Guard fix logic has been implemented</spirit:description>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>activate</spirit:name>
                        <spirit:description>When 1, and if the fix logic is implemented, it instructs the PTP Guard to fix the PTP violations it detects (and reports). Note that there is a synthesis parameter to generate the "fix" logic or not

When 0, no attempt is done to fix (even if the logic exists) and the PTP Guard will only work as a monitor and reports the violations detected.

For full details of the operation, what violations are detected and fixed, and how the fix is done, see the wiki.</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>1</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003C20</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>max_cycles</spirit:name>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00030000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_mode</spirit:name>
                        <spirit:description>This configures the mode of counting towards max_cycles:

0x0: All PTP cycles are included in the count
0x1: PTP cycles with backpressure (drdy=1'b0) are excluded from the count
0x2: PTP cycles with wait (srdy=1'b0) are excluded from the count
0x3: PTP cycles with either backpressure or wait are excluded from the count. Hence, only "absorbed" PTP cycles are included in the count

Other mode values are reserved</spirit:description>
                        <spirit:bitOffset>16</spirit:bitOffset>
                        <spirit:bitWidth>4</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0011</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>max_cycles</spirit:name>
                        <spirit:description>Sets the maximum number of clock cycles the PTP packet can last between its sop and eop taking into account the max_cycle_mode

When set to 0, it instructs the logic not to fix this violation (when the fix logic is available). However, the monitor will still issue a violation when the cycle count reaches its maximum and rollover.</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003C24</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003C20</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : config0  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                  <spirit:name>stats0</spirit:name>
                  <spirit:description>All the Statistic Registers and their configuration</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:range>0x10</spirit:range>            
                  <spirit:register>
                     <spirit:name>rd2clr_config</spirit:name>
                     <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_err</spirit:name>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_eop_err</spirit:name>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_sop_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003C28</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>missing_sop_err</spirit:name>
                     <spirit:description>Counts the number of PTP violations due to missing sop where the srdy was asserted without a prior sop assertion</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>missing_sop_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003C2C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>missing_eop_err</spirit:name>
                     <spirit:description>Counts the number of PTP violations due to missing eop where the PTP had been started but a new sop is seen without ending the previously started PTP</spirit:description>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>missing_eop_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003C30</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>max_cycle_err</spirit:name>
                     <spirit:description>Counts the number of PTP violations due to reaching the maximum allowed cycles after starting a new PTP</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003C34</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003C28</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 

  <!-- reg group
                    :irq0  --> 
          <spirit:registerFile>
                  <spirit:name>irq0</spirit:name>
                  <spirit:description>Define the IRQ group</spirit:description>
                  <spirit:addressOffset>0x1C</spirit:addressOffset>
                  <spirit:range>0x10</spirit:range>            
                  <spirit:register>
                     <spirit:name>enable</spirit:name>
                     <spirit:description>The enable for the actual interrupt signals. Writing a 1 enables the interrupt.
</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_err</spirit:name>
                        <spirit:description>Fires on PTP violations due to reaching the maximum allowed cycles after starting a new PTP</spirit:description>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_eop_err</spirit:name>
                        <spirit:description>Fires on PTP violations due to missing eop where the PTP had been started but a new sop is seen without ending the previously started PTP</spirit:description>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_sop_err</spirit:name>
                        <spirit:description>Fires on PTP violations due to missing sop where the srdy was asserted without a prior sop assertion</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003C38</address>
                           <intr.enable>irq666_ptp_guard</intr.enable>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>pending</spirit:name>
                     <spirit:description>The actual interrupt(s) that has triggered. Write a 1 to clear.
</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_err</spirit:name>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_eop_err</spirit:name>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_sop_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003C3C</address>
                           <intr.status>irq666_ptp_guard</intr.status>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>pending_irq</spirit:name>
                     <spirit:description>Registered version of pending &amp; enable.
</spirit:description>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_err</spirit:name>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_eop_err</spirit:name>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_sop_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003C40</address>
                           <intr.pending>irq666_ptp_guard</intr.pending>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>raw</spirit:name>
                     <spirit:description>The status registered values for the interrupt signals, if applicable.</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_err</spirit:name>
                        <spirit:description>Not used</spirit:description>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_eop_err</spirit:name>
                        <spirit:description>Not used</spirit:description>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_sop_err</spirit:name>
                        <spirit:description>Not used</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003C44</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003C38</address>
                        <context>ptp_guard</context>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : irq0  --> 
<spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80003C1C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : ptp_guard  --> 

  <!-- reg group
                    :irq0  --> 
          <spirit:registerFile>
               <spirit:name>irq0</spirit:name>
               <spirit:description>Define the IRQ group</spirit:description>
               <spirit:addressOffset>0x48</spirit:addressOffset>
               <spirit:range>0x10</spirit:range>            
               <spirit:register>
                  <spirit:name>enable</spirit:name>
                  <spirit:description>Indicating a rollover for that particular count has occurred
</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>de_framer_stats0_out_eop_irq_rollover</spirit:name>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>de_framer_stats0_out_sop_irq_rollover</spirit:name>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>de_framer_stats0_non_eth_pkt_irq_rollover</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003C48</address>
                        <intr.enable>irq0_layer3_rx</intr.enable>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending</spirit:name>
                  <spirit:description>Indicating a rollover for that particular count has occurred
</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>de_framer_stats0_out_eop_irq_rollover</spirit:name>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>de_framer_stats0_out_sop_irq_rollover</spirit:name>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>de_framer_stats0_non_eth_pkt_irq_rollover</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003C4C</address>
                        <intr.status>irq0_layer3_rx</intr.status>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending_irq</spirit:name>
                  <spirit:description>Registered version of pending &amp; enable
</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>de_framer_stats0_out_eop_irq_rollover</spirit:name>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>de_framer_stats0_out_sop_irq_rollover</spirit:name>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>de_framer_stats0_non_eth_pkt_irq_rollover</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003C50</address>
                        <intr.pending>irq0_layer3_rx</intr.pending>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>raw</spirit:name>
                  <spirit:description>Indicating a rollover for that particular count has occurred</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>de_framer_stats0_out_eop_irq_rollover</spirit:name>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>de_framer_stats0_out_sop_irq_rollover</spirit:name>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>de_framer_stats0_non_eth_pkt_irq_rollover</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003C54</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80003C48</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : irq0  --> 
         <spirit:vendorExtensions>
               <ids_properties>
                  <module_name>layer3_rx_regs</module_name>
                  <uvm.package>layer3_rx_regs_pkg</uvm.package>
                  <reset_type>async</reset_type>
                  <cheader.mask_endianess>little</cheader.mask_endianess>
                  <header.struct_guard>__ASSEMBLER__</header.struct_guard>
                  <explicit_name>true</explicit_name>
                  <vertical_reuse>true</vertical_reuse>
                  <address>0x80003C00</address>
               </ids_properties>
            </spirit:vendorExtensions>
         </spirit:addressBlock>     
         <spirit:addressBlock>     
            <spirit:name>mca_core</spirit:name>
            <spirit:description>MCA Channel register control
</spirit:description>  <!-- //
                        block : mca_core  --> 
            <spirit:baseAddress>0x80003D00</spirit:baseAddress>               
            <spirit:range>0x100</spirit:range>               
            <spirit:width>32</spirit:width>            
            <spirit:register>
               <spirit:name>version</spirit:name>
               <spirit:addressOffset>0x0</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:reset>
                  <spirit:value>0x00010204</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>major</spirit:name>
                  <spirit:description>Major version</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000001</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>minor</spirit:name>
                  <spirit:description>Minor version</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000010</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>patch</spirit:name>
                  <spirit:description>Patch version</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000100</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80003D00</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>control0</spirit:name>
               <spirit:addressOffset>0x4</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>dp_rx_en</spirit:name>
                  <spirit:description>Enables the datapath to receive packets</spirit:description>
                  <spirit:bitOffset>1</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>dp_tx_en</spirit:name>
                  <spirit:description>Enables the datapath to transmit packets</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80003D04</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>status0</spirit:name>
               <spirit:addressOffset>0x8</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>dp_rx_ready</spirit:name>
                  <spirit:description>Indicates the datapath is ready for transmission</spirit:description>
                  <spirit:bitOffset>1</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>dp_tx_ready</spirit:name>
                  <spirit:description>Indicates the datapath is ready for reception</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80003D08</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>
  <!-- reg group
                    :link  --> 
          <spirit:registerFile>
               <spirit:name>link</spirit:name>
               <spirit:description>This register group contains channel based link management controls and status information.</spirit:description>
               <spirit:addressOffset>0xC</spirit:addressOffset>
               <spirit:range>0x38</spirit:range>
  <!-- reg group
                    :control0  --> 
          <spirit:registerFile>
                  <spirit:name>control0</spirit:name>
                  <spirit:description>This register group contains channel based link management controls and status information.</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:range>0x34</spirit:range>            
                  <spirit:register>
                     <spirit:name>ltssm_pkt_mngt_pol</spirit:name>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00184184</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>rx_idl_en_min</spirit:name>
                        <spirit:description>Sets the minimum number of idle packets that must be received before starting to count the locally transmitted ts1.</spirit:description>
                        <spirit:bitOffset>20</spirit:bitOffset>
                        <spirit:bitWidth>4</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0001</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>tx_idl_min</spirit:name>
                        <spirit:description>Sets the minimum number of idle packets which must be transmitted before moving to the u0 state.</spirit:description>
                        <spirit:bitOffset>16</spirit:bitOffset>
                        <spirit:bitWidth>4</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>1000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>rx_idl_min</spirit:name>
                        <spirit:description>Sets minimum number of idle packets which must be received before moving to the u0 state.</spirit:description>
                        <spirit:bitOffset>12</spirit:bitOffset>
                        <spirit:bitWidth>4</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0100</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>rx_ts1_en_min</spirit:name>
                        <spirit:description>Sets the minimum number of ts1 packets that must be received before starting to count the locally transmitted ts1.</spirit:description>
                        <spirit:bitOffset>8</spirit:bitOffset>
                        <spirit:bitWidth>4</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0001</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>tx_ts1_min</spirit:name>
                        <spirit:description>Sets the minimum number of ts1 packets which must be transmitted before moving to the polling_idle state.</spirit:description>
                        <spirit:bitOffset>4</spirit:bitOffset>
                        <spirit:bitWidth>4</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>1000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>rx_ts1_min</spirit:name>
                        <spirit:description>Sets minimum number of ts1 packets which must be received before moving to the polling_idle state.</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>4</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0100</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003D0C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>ltssm_pkt_mngt_rec</spirit:name>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00141141</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>rx_idl_en_max_lmt</spirit:name>
                        <spirit:description>Sets the minimum number of idle packets that must be received before starting to count the locally transmitted ts2.</spirit:description>
                        <spirit:bitOffset>20</spirit:bitOffset>
                        <spirit:bitWidth>4</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0001</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>tx_idl_max_lmt</spirit:name>
                        <spirit:description>Sets the minimum number of idle packets which must be transmitted before moving to the u0 state.</spirit:description>
                        <spirit:bitOffset>16</spirit:bitOffset>
                        <spirit:bitWidth>4</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0100</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>rx_idl_max_lmt</spirit:name>
                        <spirit:description>Sets minimum number of idle packets which must be received before moving to the u0 state.</spirit:description>
                        <spirit:bitOffset>12</spirit:bitOffset>
                        <spirit:bitWidth>4</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0001</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>rx_ts2_en_max_lmt</spirit:name>
                        <spirit:description>Sets the minimum number of ts2 packets that must be received before starting to count the locally transmitted ts1.</spirit:description>
                        <spirit:bitOffset>8</spirit:bitOffset>
                        <spirit:bitWidth>4</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0001</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>tx_ts2_max_lmt</spirit:name>
                        <spirit:description>Sets the minimum number of ts2 packets which must be transmitted before moving to the rec_idle state.</spirit:description>
                        <spirit:bitOffset>4</spirit:bitOffset>
                        <spirit:bitWidth>4</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0100</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>rx_ts2_max_lmt</spirit:name>
                        <spirit:description>Sets minimum number of ts2 packets which must be received before moving to the rec_idle state.</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>4</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0001</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003D10</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
  <!-- reg group
                    :ltssm_pol_tmr  --> 
          <spirit:registerFile>
                     <spirit:name>ltssm_pol_tmr</spirit:name>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:range>0xC</spirit:range>            
                     <spirit:register>
                        <spirit:name>act_rpt</spirit:name>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x000001D5</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>lmt</spirit:name>
                           <spirit:description>This timer determine the rate at which ts1 packets are transmitted during polling_active
(default approximately 3us)</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>32</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000000000000000000111010101</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80003D14</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>idle_rpt</spirit:name>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x000001D5</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>lmt</spirit:name>
                           <spirit:description>This timer determine the rate at which idle packets are transmitted during polling_idle
(default approximately 3us)</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>32</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000000000000000000111010101</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80003D18</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>idle</spirit:name>
                        <spirit:addressOffset>0x8</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x0002625A</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>lmt</spirit:name>
                           <spirit:description>When in polling_ilde this timer determine how long to wait before re-starting the polling_active state.
(default approximately 1ms)</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>32</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000000000100110001001011010</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80003D1C</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003D14</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : ltssm_pol_tmr  --> 

  <!-- reg group
                    :ltssm_rec_tmr  --> 
          <spirit:registerFile>
                     <spirit:name>ltssm_rec_tmr</spirit:name>
                     <spirit:addressOffset>0x14</spirit:addressOffset>
                     <spirit:range>0xC</spirit:range>            
                     <spirit:register>
                        <spirit:name>act_rpt</spirit:name>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000028</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>lmt</spirit:name>
                           <spirit:description>This timer determine the rate at which ts2 packets are transmitted during rec_active.
(default approximately 0.25us)</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>32</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000000000000000000000101000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80003D20</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>idle_rpt</spirit:name>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000028</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>lmt</spirit:name>
                           <spirit:description>This timer determine the rate at which idle packets are transmitted during rec_idle
(default approximately 0.25us)</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>32</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000000000000000000000101000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80003D24</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>idle</spirit:name>
                        <spirit:addressOffset>0x8</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x0002625A</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>lmt</spirit:name>
                           <spirit:description>When in rec_ilde this timer determine how long to wait before declaring a recovery failure and declaring the port in-active.
(default approximately 1ms)</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>32</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000000000100110001001011010</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80003D28</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003D20</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : ltssm_rec_tmr  --> 

  <!-- reg group
                    :ltssm_u0_tmr  --> 
          <spirit:registerFile>
                     <spirit:name>ltssm_u0_tmr</spirit:name>
                     <spirit:addressOffset>0x20</spirit:addressOffset>
                     <spirit:range>0x10</spirit:range>            
                     <spirit:register>
                        <spirit:name>u0ltimeout</spirit:name>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x0000061B</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>lmt</spirit:name>
                           <spirit:description>When operating in U0 this timer defines the rate at which the system transmits keep alive packets (note these are only done in absence of transmitting data).
(default approximately 10us)</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>32</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000000000000000011000011011</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80003D2C</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pnd</spirit:name>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00003D09</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>lmt</spirit:name>
                           <spirit:description>This timer sets the maximum time limit to wait for a response to be received from the remote port to a retry-able MCUP
(default approximately 100us)</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>32</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000000000000011110100001001</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80003D30</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>crd</spirit:name>
                        <spirit:addressOffset>0x8</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00003D09</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>lmt</spirit:name>
                           <spirit:description>This sets the credit timeout.not implemented yet.
(default approximately 100us)</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>32</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000000000000011110100001001</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80003D34</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>u0rectimeout</spirit:name>
                        <spirit:addressOffset>0xC</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x0001312D</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>lmt</spirit:name>
                           <spirit:description>This timer sets the limit on how long to wait without seeing received traffic (link ups/data etc) from the remote end.
(default approximately 500us)</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>32</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000000000010011000100101101</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80003D38</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003D2C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : ltssm_u0_tmr  --> 

  <!-- reg group
                    :test  --> 
          <spirit:registerFile>
                     <spirit:name>test</spirit:name>
                     <spirit:addressOffset>0x30</spirit:addressOffset>
                     <spirit:range>0x4</spirit:range>            
                     <spirit:register>
                        <spirit:name>latency</spirit:name>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00003D09</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>lmt</spirit:name>
                           <spirit:description>This timer sets the rate at which the latency packet sequence is transmitted. Results are stored in the channel associated with the test.
(default approximately 100us)</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>32</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000000000000011110100001001</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80003D3C</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003D3C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : test  --> 
<spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003D0C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : control0  --> 

  <!-- reg group
                    :status0  --> 
          <spirit:registerFile>
                  <spirit:name>status0</spirit:name>
                  <spirit:addressOffset>0x34</spirit:addressOffset>
                  <spirit:range>0x4</spirit:range>            
                  <spirit:register>
                     <spirit:name>cfg</spirit:name>
                     <spirit:description>General configuration settings for the link management logic</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>active_channels</spirit:name>
                        <spirit:description>Indicates how many channels are used in this instance of the MCA.</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>5</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003D40</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003D40</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : status0  --> 
<spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80003D0C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : link  --> 

  <!-- reg group
                    :tx  --> 
          <spirit:registerFile>
               <spirit:name>tx</spirit:name>
               <spirit:addressOffset>0x44</spirit:addressOffset>
               <spirit:range>0x44</spirit:range>
  <!-- reg group
                    :control0  --> 
          <spirit:registerFile>
                  <spirit:name>control0</spirit:name>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:range>0x8</spirit:range>            
                  <spirit:register>
                     <spirit:name>dp</spirit:name>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>stats_chid_en</spirit:name>
                        <spirit:description>This field is represents the bit vector which selects the channel(s) which participate in the statistics collection.

Bit X
1 - Include channel in statistics collection
0 - Exclude channel from statistics collection
</spirit:description>
                        <spirit:bitOffset>8</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>bw_pkt_type</spirit:name>
                        <spirit:description>Defines the packet types which bandwidth measurements are taken measured at the egress of the MCA.
0 - all packet types 
1 - lgood 
2 - lcrd 
3 - retriable mcup 
4 - non-retriable mcup</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>4</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003D44</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>bw_sample_timer</spirit:name>
                     <spirit:description>This register defines the sample period all bandwidth monitors use to calculate the average bandwidth. The clock reference is the core clock.</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x000000FF</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:description>Defines the periodicity of the bandwidth sample clock</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000011111111</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003D48</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003D44</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : control0  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                  <spirit:name>stats0</spirit:name>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:range>0x3C</spirit:range>            
                  <spirit:register>
                     <spirit:name>rd2clr_config</spirit:name>
                     <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>bandwidth</spirit:name>
                        <spirit:bitOffset>13</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>plu</spirit:name>
                        <spirit:bitOffset>12</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>lgood</spirit:name>
                        <spirit:bitOffset>11</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>lcrd</spirit:name>
                        <spirit:bitOffset>10</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>lrtry</spirit:name>
                        <spirit:bitOffset>9</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>lbad</spirit:name>
                        <spirit:bitOffset>8</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>ts1</spirit:name>
                        <spirit:bitOffset>7</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>ts2</spirit:name>
                        <spirit:bitOffset>6</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>idle</spirit:name>
                        <spirit:bitOffset>5</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>data_pkt_rtry</spirit:name>
                        <spirit:bitOffset>4</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>data_pkt_nrtry</spirit:name>
                        <spirit:bitOffset>3</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>cmd_fifo_dcount</spirit:name>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>nfifo</spirit:name>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>pfifo</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003D4C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>pfifo</spirit:name>
                     <spirit:description>Packet FIFO level. This is fixed at 16 elements (16 * 8= 128 bytes)</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>4</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003D50</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>nfifo</spirit:name>
                     <spirit:description>Notification FIFO level. This represents the number of MCUPS in the egress FIFO</spirit:description>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>4</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003D54</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>cmd_fifo_dcount</spirit:name>
                     <spirit:description>This is the common TX Command FIFO level.All channels send link commands through this FIFO</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003D58</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>data_pkt_nrtry</spirit:name>
                     <spirit:description>This represents the number of non-retriable data-packets are being sent</spirit:description>
                     <spirit:addressOffset>0x10</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003D5C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>data_pkt_rtry</spirit:name>
                     <spirit:description>This is the number of retriable packets which have been transmitted</spirit:description>
                     <spirit:addressOffset>0x14</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003D60</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>idle</spirit:name>
                     <spirit:description>Number if idle packets transmitted. These should be relatively low so this counter is small.</spirit:description>
                     <spirit:addressOffset>0x18</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003D64</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>ts2</spirit:name>
                     <spirit:description>Number if ts2 packets transmitted. These should be relatively low so this counter is small.</spirit:description>
                     <spirit:addressOffset>0x1C</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003D68</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>ts1</spirit:name>
                     <spirit:description>Number if ts1 packets transmitted. These should be relatively low so this counter is small.</spirit:description>
                     <spirit:addressOffset>0x20</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003D6C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>lbad</spirit:name>
                     <spirit:description>Number of LBAD packets transmitted.</spirit:description>
                     <spirit:addressOffset>0x24</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003D70</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>lrtry</spirit:name>
                     <spirit:description>Number of retry requests sent to the remote end</spirit:description>
                     <spirit:addressOffset>0x28</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003D74</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>lcrd</spirit:name>
                     <spirit:description>Number of credit packets transmitted.</spirit:description>
                     <spirit:addressOffset>0x2C</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003D78</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>lgood</spirit:name>
                     <spirit:description>Number of LGOOD packets transmitted.</spirit:description>
                     <spirit:addressOffset>0x30</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003D7C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>plu</spirit:name>
                     <spirit:description>Number of keep alive packets transmitted</spirit:description>
                     <spirit:addressOffset>0x34</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003D80</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>bandwidth</spirit:name>
                     <spirit:description>This register reports the high level watermark of the egress bandwidth.
*NOTE: this depends on the configuration which packets types are measured</spirit:description>
                     <spirit:addressOffset>0x38</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003D84</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003D4C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 
<spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80003D44</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : tx  --> 

  <!-- reg group
                    :rx  --> 
          <spirit:registerFile>
               <spirit:name>rx</spirit:name>
               <spirit:addressOffset>0x88</spirit:addressOffset>
               <spirit:range>0x3C</spirit:range>
  <!-- reg group
                    :control0  --> 
          <spirit:registerFile>
                  <spirit:name>control0</spirit:name>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:range>0x8</spirit:range>            
                  <spirit:register>
                     <spirit:name>dp</spirit:name>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>stats_chid_en</spirit:name>
                        <spirit:description>This field is represents the bit vector which selects the channel(s) which participate in the statistics collection.

Bit X
1 - Include channel in statistics collection
0 - Exclude channel from statistics collection
</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003D88</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>rx_cmd_fifo_flc</spirit:name>
                     <spirit:description>The RX command flow control sets the hysteresis points which enable or disable flow control globally on the data-path.

The RX command FIFO contains all responses generated from the RX link management logic. This is a relatively large FIFO and is designed to hold more data than the TX channel FIFO's.

Commands in this FIFO are critical and must not be lost. When the FIFO reaches its upper limit it will prevent transmission of data payloads over the link allowing a bias to the TX command FIFO's to drain, and henceforth allowing the RX command FIFO to drain.
</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00630001</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>hi</spirit:name>
                        <spirit:description>When the FIFO reaches this limit the system will enter flow control.</spirit:description>
                        <spirit:bitOffset>16</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000001100011</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>lo</spirit:name>
                        <spirit:description>When the FIFO threshold reaches this threshold flow control will be disabled and normal operation can occur.</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000001</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003D8C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003D88</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : control0  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                  <spirit:name>stats0</spirit:name>
                  <spirit:description>All the Statistic Registers and their configuration for the Write Engine</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:range>0x34</spirit:range>            
                  <spirit:register>
                     <spirit:name>rd2clr_config</spirit:name>
                     <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>rx_cmd_fifo_flc</spirit:name>
                        <spirit:bitOffset>11</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>plu</spirit:name>
                        <spirit:bitOffset>10</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>lgood</spirit:name>
                        <spirit:bitOffset>9</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>lcrd</spirit:name>
                        <spirit:bitOffset>8</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>lrtry</spirit:name>
                        <spirit:bitOffset>7</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>lbad</spirit:name>
                        <spirit:bitOffset>6</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>ts1</spirit:name>
                        <spirit:bitOffset>5</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>ts2</spirit:name>
                        <spirit:bitOffset>4</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>idle</spirit:name>
                        <spirit:bitOffset>3</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>data_pkt_rtry</spirit:name>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>data_pkt_nrtry</spirit:name>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>cmd_fifo_dcount</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003D90</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>cmd_fifo_dcount</spirit:name>
                     <spirit:description>This is the common RX Command FIFO level.All channels receive link commands through this FIFO</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003D94</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>data_pkt_nrtry</spirit:name>
                     <spirit:description>This represents the number of non-retriable data-packets received</spirit:description>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003D98</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>data_pkt_rtry</spirit:name>
                     <spirit:description>This is the number of retriable packets which have been received</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003D9C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>idle</spirit:name>
                     <spirit:description>Number of idle packets received. These should be relatively low so this counter is small.</spirit:description>
                     <spirit:addressOffset>0x10</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003DA0</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>ts2</spirit:name>
                     <spirit:description>Number of ts2 packets received. These should be relatively low so this counter is small.</spirit:description>
                     <spirit:addressOffset>0x14</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003DA4</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>ts1</spirit:name>
                     <spirit:description>Number of ts1 packets received. These should be relatively low so this counter is small.</spirit:description>
                     <spirit:addressOffset>0x18</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003DA8</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>lbad</spirit:name>
                     <spirit:description>Number of LBAD packets received.</spirit:description>
                     <spirit:addressOffset>0x1C</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003DAC</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>lrtry</spirit:name>
                     <spirit:description>Number of retry requests sent to the remote end</spirit:description>
                     <spirit:addressOffset>0x20</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003DB0</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>lcrd</spirit:name>
                     <spirit:description>Number of credit packets received.</spirit:description>
                     <spirit:addressOffset>0x24</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003DB4</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>lgood</spirit:name>
                     <spirit:description>Number of LGOOD packets transmitted.</spirit:description>
                     <spirit:addressOffset>0x28</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003DB8</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>plu</spirit:name>
                     <spirit:description>Number of keep alive packets received</spirit:description>
                     <spirit:addressOffset>0x2C</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003DBC</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>rx_cmd_fifo_flc</spirit:name>
                     <spirit:description>Counts the number of clock cycles the RX command FIFO flow control state has been active</spirit:description>
                     <spirit:addressOffset>0x30</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003DC0</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003D90</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 
<spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80003D88</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : rx  --> 

  <!-- reg group
                    :irq0  --> 
          <spirit:registerFile>
               <spirit:name>irq0</spirit:name>
               <spirit:description>MCA channel interrupts</spirit:description>
               <spirit:addressOffset>0xC4</spirit:addressOffset>
               <spirit:range>0x10</spirit:range>            
               <spirit:register>
                  <spirit:name>enable</spirit:name>
                  <spirit:description>Interrupt Enable register - Write 1 to enable, 0 to mask an interrupt
</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>rx_dp_grd_sop_err</spirit:name>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_dp_grd_eop_err</spirit:name>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_dp_grd_max_err</spirit:name>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_lnk_cmd_fifo_full_err</spirit:name>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_lnk_cmd_fifo_full_err</spirit:name>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_dp_grd_sop_err</spirit:name>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_dp_grd_eop_err</spirit:name>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_dp_grd_max_err</spirit:name>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_dp_fifo_drp_pkt_wr</spirit:name>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_dp_fifo_drp_pkt_rd</spirit:name>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_dp_fifo_pkt_sop_err</spirit:name>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_dp_fifo_pkt_err</spirit:name>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_dp_fifo_full_err</spirit:name>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_dp_fifo_pkt_max_sz_err</spirit:name>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_drp_pkt</spirit:name>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_ready</spirit:name>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_rx_ready</spirit:name>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_tx_ready</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003DC4</address>
                        <intr.enable>irq0_mca_core</intr.enable>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending</spirit:name>
                  <spirit:description>Interrupt Pending register - This indicates which enabled interrupts have triggered, Write 1 to clear
</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>rx_dp_grd_sop_err</spirit:name>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_dp_grd_eop_err</spirit:name>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_dp_grd_max_err</spirit:name>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_lnk_cmd_fifo_full_err</spirit:name>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_lnk_cmd_fifo_full_err</spirit:name>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_dp_grd_sop_err</spirit:name>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_dp_grd_eop_err</spirit:name>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_dp_grd_max_err</spirit:name>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_dp_fifo_drp_pkt_wr</spirit:name>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_dp_fifo_drp_pkt_rd</spirit:name>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_dp_fifo_pkt_sop_err</spirit:name>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_dp_fifo_pkt_err</spirit:name>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_dp_fifo_full_err</spirit:name>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_dp_fifo_pkt_max_sz_err</spirit:name>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_drp_pkt</spirit:name>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_ready</spirit:name>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_rx_ready</spirit:name>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_tx_ready</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003DC8</address>
                        <intr.status>irq0_mca_core</intr.status>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending_irq</spirit:name>
                  <spirit:description>Interrupt Pending register - This indicates which enabled interrupts have been triggered, Write 1 to clear
</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>rx_dp_grd_sop_err</spirit:name>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_dp_grd_eop_err</spirit:name>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_dp_grd_max_err</spirit:name>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_lnk_cmd_fifo_full_err</spirit:name>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_lnk_cmd_fifo_full_err</spirit:name>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_dp_grd_sop_err</spirit:name>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_dp_grd_eop_err</spirit:name>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_dp_grd_max_err</spirit:name>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_dp_fifo_drp_pkt_wr</spirit:name>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_dp_fifo_drp_pkt_rd</spirit:name>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_dp_fifo_pkt_sop_err</spirit:name>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_dp_fifo_pkt_err</spirit:name>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_dp_fifo_full_err</spirit:name>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_dp_fifo_pkt_max_sz_err</spirit:name>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_drp_pkt</spirit:name>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_ready</spirit:name>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_rx_ready</spirit:name>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_tx_ready</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003DCC</address>
                        <intr.pending>irq0_mca_core</intr.pending>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>raw</spirit:name>
                  <spirit:description>This register contains the active state of interrupt sources</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>rx_dp_grd_sop_err</spirit:name>
                     <spirit:description>Pulse. Critical Error</spirit:description>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_dp_grd_eop_err</spirit:name>
                     <spirit:description>Pulse. Critical Error</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_dp_grd_max_err</spirit:name>
                     <spirit:description>Pulse. Critical Error</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_lnk_cmd_fifo_full_err</spirit:name>
                     <spirit:description>(Active High)-rising edge-Critical Error</spirit:description>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_lnk_cmd_fifo_full_err</spirit:name>
                     <spirit:description>(Active High)-rising edge-Critical Error</spirit:description>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_dp_grd_sop_err</spirit:name>
                     <spirit:description>Pulse. Critical Error</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_dp_grd_eop_err</spirit:name>
                     <spirit:description>Pulse. Critical Error</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_dp_grd_max_err</spirit:name>
                     <spirit:description>Pulse. Critical Error</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_dp_fifo_drp_pkt_wr</spirit:name>
                     <spirit:description>Pulse. Critical Error</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_dp_fifo_drp_pkt_rd</spirit:name>
                     <spirit:description>Pulse. Critical Error</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_dp_fifo_pkt_sop_err</spirit:name>
                     <spirit:description>Pulse. Critical Error</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_dp_fifo_pkt_err</spirit:name>
                     <spirit:description>(Active High)-rising edge-Critical Error</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_dp_fifo_full_err</spirit:name>
                     <spirit:description>(Active High)-rising edge-Critical Error</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_dp_fifo_pkt_max_sz_err</spirit:name>
                     <spirit:description>Pulse. Critical Error</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_dp_fifo_drp_pkt</spirit:name>
                     <spirit:description>Pulse. Critical Error</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_ready</spirit:name>
                     <spirit:description>(Active-High), rising and falling edge</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_rx_ready</spirit:name>
                     <spirit:description>(Active-High), rising and falling edge</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_tx_ready</spirit:name>
                     <spirit:description>(Active-High), rising and falling edge</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003DD0</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80003DC4</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : irq0  --> 
         <spirit:vendorExtensions>
               <ids_properties>
                  <module_name>mca_core_regs</module_name>
                  <uvm.package>mca_core_regs_pkg</uvm.package>
                  <reset_type>async</reset_type>
                  <cheader.mask_endianess>little</cheader.mask_endianess>
                  <header.struct_guard>__ASSEMBLER__</header.struct_guard>
                  <explicit_name>true</explicit_name>
                  <vertical_reuse>true</vertical_reuse>
                  <address>0x80003D00</address>
               </ids_properties>
            </spirit:vendorExtensions>
         </spirit:addressBlock>     
         <spirit:addressBlock>     
            <spirit:name>mca_channel</spirit:name>
            <spirit:description>MCA Channel register control
</spirit:description>  <!-- //
                        block : mca_channel  --> 
            <spirit:baseAddress>0x80003E00</spirit:baseAddress>               
            <spirit:range>0x100</spirit:range>               
            <spirit:width>32</spirit:width>            
            <spirit:register>
               <spirit:name>version</spirit:name>
               <spirit:addressOffset>0x0</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:reset>
                  <spirit:value>0x00010204</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>major</spirit:name>
                  <spirit:description>Major version</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000001</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>minor</spirit:name>
                  <spirit:description>Minor version</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000010</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>patch</spirit:name>
                  <spirit:description>Patch version</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000100</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80003E00</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>control0</spirit:name>
               <spirit:addressOffset>0x4</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>auto_reconnect</spirit:name>
                  <spirit:description>When this bit is set it will allow the link to automatically establish a new connection after it detects the remote port has disconnected.
0-disable
1-enable</spirit:description>
                  <spirit:bitOffset>4</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>tx_en</spirit:name>
                  <spirit:description>Allows the TX logic to initialize and prepare for the movement of data between the local and remote port. After the port is initialized and capable of processing a corresponding ready bit will be set in the status0 register indicating so.
0 - Places the transmit data-path into a disable state. This state is used to
1 - Enables the transmit data-path for the local channel to initialize and prepare to move data.</spirit:description>
                  <spirit:bitOffset>2</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>rx_en</spirit:name>
                  <spirit:description>Allows the RX logic to initialize and prepare for the movement of data from the MCA to the application. After the port is initialized and capable of processing data a corresponding ready bit will be set in the status register indicating so.
0 - Forces RX logic into a disabled state
1 - Allows the RX logic to initialize and enter a state where data can be processed.</spirit:description>
                  <spirit:bitOffset>1</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>lnk_en</spirit:name>
                  <spirit:description>This register bit enables the link to establish a virtual connection to its remote ends (i.e. enables the LTSSM). This does not rely on the RX or TX components of the channel to be enabled. Upon connection a corresponding status bit will be set indicating that the logic connection has been established.
0 - Forces the channel into the disabled state
1 = Enables the link to establish a connection to the far end.</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80003E04</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>status0</spirit:name>
               <spirit:addressOffset>0x8</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>rx_rdy</spirit:name>
                  <spirit:description>Indicates the channel RX logic is ready to process data.</spirit:description>
                  <spirit:bitOffset>3</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>tx_rdy</spirit:name>
                  <spirit:description>Indicates the channel TX logic is ready to process data.</spirit:description>
                  <spirit:bitOffset>2</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>lnk_rdy</spirit:name>
                  <spirit:description>This indicates that the LINK has entered U0 mode and the data-path is able to move data.</spirit:description>
                  <spirit:bitOffset>1</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>ch_rdy</spirit:name>
                  <spirit:description>Indicates that the link, RX, and TX components of the channel are in a state which will allow client data exchange.</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80003E08</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>
  <!-- reg group
                    :link  --> 
          <spirit:registerFile>
               <spirit:name>link</spirit:name>
               <spirit:description>This register group contains channel based link management controls and status information.</spirit:description>
               <spirit:addressOffset>0xC</spirit:addressOffset>
               <spirit:range>0x2C</spirit:range>
  <!-- reg group
                    :control0  --> 
          <spirit:registerFile>
                  <spirit:name>control0</spirit:name>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:range>0x8</spirit:range>            
                  <spirit:register>
                     <spirit:name>ltssm</spirit:name>
                     <spirit:description>This register manages the LTSSM</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000F77</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>crd_lmt_en</spirit:name>
                        <spirit:description>Disables the credit pending timer.
0-disable
1-enable</spirit:description>
                        <spirit:bitOffset>11</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>1</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>pnd_lmt_en</spirit:name>
                        <spirit:description>Disables the U0 packet pending timer.
0-disable
1-enable</spirit:description>
                        <spirit:bitOffset>10</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>1</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>u0rectimeout_lmt_en</spirit:name>
                        <spirit:description>Disables the activity timer when in U0.
0-disable
1-enable</spirit:description>
                        <spirit:bitOffset>9</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>1</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>u0ltimeout_lmt_en</spirit:name>
                        <spirit:description>Timer used to generate link up broadcasts
0-disable
1-enable</spirit:description>
                        <spirit:bitOffset>8</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>1</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>rec_idl_lmt_en</spirit:name>
                        <spirit:description>Master recovery completion timer.
0-disable
1-enable</spirit:description>
                        <spirit:bitOffset>6</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>1</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>rec_idl_rpt_en</spirit:name>
                        <spirit:description>Recovery idle repeat timer.
0-disable
1-enable</spirit:description>
                        <spirit:bitOffset>5</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>1</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>rec_act_rpt_en</spirit:name>
                        <spirit:description>Disables the recovery active repeat timer.
0-disable
1-enable</spirit:description>
                        <spirit:bitOffset>4</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>1</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>pol_idl_lmt_en</spirit:name>
                        <spirit:description>Disables the master polling completion timer.
0-disable
1-enable</spirit:description>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>1</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>pol_idl_rpt_en</spirit:name>
                        <spirit:description>Disables the polling idle repeat timer.
0-disable
1-enable</spirit:description>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>1</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>pol_act_rpt_en</spirit:name>
                        <spirit:description>Disables the polling active repeat timer.
0-disable
1-enable</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>1</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003E0C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>test</spirit:name>
                     <spirit:description>This register manages the LTSSM</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>force_bad_lcrd</spirit:name>
                        <spirit:description>This bit forces the link to treat the next received lcrd command as if it were received in error. 
</spirit:description>
                        <spirit:bitOffset>8</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                           <ids_properties>
                              <rtl.hw_clear>1</rtl.hw_clear>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>force_bad_lgood</spirit:name>
                        <spirit:description>This bit forces the link to treat the next received lgood command as if it were received in error. 
</spirit:description>
                        <spirit:bitOffset>7</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                           <ids_properties>
                              <rtl.hw_clear>1</rtl.hw_clear>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>force_bad_data_nrtry</spirit:name>
                        <spirit:description>This bit forces the link receiver to treat the next non retriable packet as if it was received in error. 
</spirit:description>
                        <spirit:bitOffset>6</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                           <ids_properties>
                              <rtl.hw_clear>1</rtl.hw_clear>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>force_bad_data_rtry</spirit:name>
                        <spirit:description>This bit forces the link receiver to treat the next retriable packet as if it was received in error. 
</spirit:description>
                        <spirit:bitOffset>5</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                           <ids_properties>
                              <rtl.hw_clear>1</rtl.hw_clear>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>go2_recovery</spirit:name>
                        <spirit:description>This bit forces the local LTSSM into a recovery action. This is intended for lab testing. This bit is cleared as soon as the LTSSM enters the recovery state.
</spirit:description>
                        <spirit:bitOffset>4</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                           <ids_properties>
                              <rtl.hw_clear>1</rtl.hw_clear>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>dp_tx_hdr_ovrd_time</spirit:name>
                        <spirit:description>This bit controls where the system time stamp is inserted at.
1 - At the final stage before the output of the MCA.TX to the link.
0- At the arbitration input</spirit:description>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>measure_latency</spirit:name>
                        <spirit:description>Enables the round trip latency transactions protocol for this channel.</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003E10</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003E0C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : control0  --> 

  <!-- reg group
                    :status0  --> 
          <spirit:registerFile>
                  <spirit:name>status0</spirit:name>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:range>0x4</spirit:range>            
                  <spirit:register>
                     <spirit:name>ltssm</spirit:name>
                     <spirit:description>Current State for LTSSM.</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>rec_idl</spirit:name>
                        <spirit:description>This port indicates that the ports are resynchronized and they are ready to enter back to U0.</spirit:description>
                        <spirit:bitOffset>6</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>rec_act</spirit:name>
                        <spirit:description>Indicates the port is in recovery and is waiting for the remote end to acknowledge the recovery action.</spirit:description>
                        <spirit:bitOffset>5</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>u0</spirit:name>
                        <spirit:description>Indicates that the port is now in operating state where application data can be transmitted between the two ports.</spirit:description>
                        <spirit:bitOffset>4</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>pol_idl</spirit:name>
                        <spirit:description>This bit indicates that the LTSSM has found the far end port and is waiting for the far end port to acknowledge that it has discovered this port.</spirit:description>
                        <spirit:bitOffset>3</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>pol_act</spirit:name>
                        <spirit:description>This bit indicates the link is in the polling state. Polling is a discovery of the existence of a remote port.</spirit:description>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>dis</spirit:name>
                        <spirit:description>Indicates the LTSSM is in state disable. This is the default state from reset. As soon as software sets the link enable bit this state will transition to polling active.</spirit:description>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>inact</spirit:name>
                        <spirit:description>When in the inactive state software must clear the link enable bit and only enable it once the dis bit is set. This state is entered if the far end is disabled and re-enabled (i.e. entered polling) or if the recovery action timed out instead of completing the action.</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003E14</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003E14</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : status0  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                  <spirit:name>stats0</spirit:name>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:range>0x20</spirit:range>            
                  <spirit:register>
                     <spirit:name>rd2clr_config</spirit:name>
                     <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>latency</spirit:name>
                        <spirit:bitOffset>6</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>rx_mcup</spirit:name>
                        <spirit:bitOffset>5</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>rx_frm</spirit:name>
                        <spirit:bitOffset>4</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>tx_mcup</spirit:name>
                        <spirit:bitOffset>3</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>tx_frm</spirit:name>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>pol_fail</spirit:name>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>u0_to_rec</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003E18</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>u0_to_rec</spirit:name>
                     <spirit:description>This register keeps track of the number of times the LTSSM state enters recovery from u0. This is not an error condition as much as it is a indication of general link health.</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003E1C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>pol_fail</spirit:name>
                     <spirit:description>This registers counts the number of times polling failed to get a idle response after detecting a remote training packet (resulting in the return to polling)</spirit:description>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003E20</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>tx_frm</spirit:name>
                     <spirit:description>This counts the application side packets being transmitted through the channel</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003E24</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>tx_mcup</spirit:name>
                     <spirit:description>This counts the number of MCUP's transmitted due to transmitting the application data</spirit:description>
                     <spirit:addressOffset>0x10</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003E28</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>rx_frm</spirit:name>
                     <spirit:description>This counts the application side packets being transmitted through the channel</spirit:description>
                     <spirit:addressOffset>0x14</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003E2C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>rx_mcup</spirit:name>
                     <spirit:description>This counts the number of MCUP's transmitted due to transmitting the application data</spirit:description>
                     <spirit:addressOffset>0x18</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003E30</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>latency</spirit:name>
                     <spirit:description>This reports the high water mark for the round trip latency measurement</spirit:description>
                     <spirit:addressOffset>0x1C</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003E34</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003E18</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 
<spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80003E0C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : link  --> 

  <!-- reg group
                    :tx  --> 
          <spirit:registerFile>
               <spirit:name>tx</spirit:name>
               <spirit:addressOffset>0x38</spirit:addressOffset>
               <spirit:range>0x44</spirit:range>
  <!-- reg group
                    :control0  --> 
          <spirit:registerFile>
                  <spirit:name>control0</spirit:name>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:range>0x10</spirit:range>            
                  <spirit:register>
                     <spirit:name>dp</spirit:name>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00080000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>mcup_pld_max_cycles</spirit:name>
                        <spirit:description>This indicates the maximum size an MCUP payload will be limited to. The MCUP size is calculated as follows:
(bytes_per_clock_cycle*mcup_pld_max_size)+(bytes_per_clock_cycle-mcup_header_size)
eg. for 8 bytes per clock cycle, and a header size of 4 bytes, and a default value of 8:
(8*8)+(8-4) = 68</spirit:description>
                        <spirit:bitOffset>16</spirit:bitOffset>
                        <spirit:bitWidth>4</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>1000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>force_retry</spirit:name>
                        <spirit:description>This bit will force the channel to support the retry behavior on all its packets. This bit overrides the block_retry bit.</spirit:description>
                        <spirit:bitOffset>13</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>block_retry</spirit:name>
                        <spirit:description>This bit will prevent all packets transmitted on this channel from supporting the retry behavior.</spirit:description>
                        <spirit:bitOffset>12</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>bw_src</spirit:name>
                        <spirit:description>Bandwidth measurements are derived before the fragmentation (i.e. raw bandwidth) or after the fragmentation logic.</spirit:description>
                        <spirit:bitOffset>8</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>drp_on_pkt_err</spirit:name>
                        <spirit:description>If a packet error is received during the notification point this bit will cause the FIFO to drop the packet.</spirit:description>
                        <spirit:bitOffset>5</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>flw_ctrl_en</spirit:name>
                        <spirit:description>Used to enable or disable flow control from the TX FIFO.</spirit:description>
                        <spirit:bitOffset>4</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>hys_en</spirit:name>
                        <spirit:description>If this is set the hysteresis flag will be set or cleared based on the FIFO depth.</spirit:description>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>drp_on_sop</spirit:name>
                        <spirit:description>1 - All packets will be dropped at the input of the FIFO
0 - Normal operation</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003E38</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>rtry_buf</spirit:name>
                     <spirit:description>Retry buffer base address</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>base_addr</spirit:name>
                        <spirit:description>This register sets the base address for the channels retry buffer.</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003E3C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>fifo_hys</spirit:name>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>hi</spirit:name>
                        <spirit:description>Sets the upper FIFO level at which the hysteresis will be set. This value is based on FIFO words and not bytes.</spirit:description>
                        <spirit:bitOffset>16</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>lo</spirit:name>
                        <spirit:description>Sets the lower FIFO level at which the hysteresis will be cleared. This value is based on FIFO words and not bytes.</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003E40</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>bandwidth_limit</spirit:name>
                     <spirit:description>This register defines the bandwidth range which the channel can consume. If the upper range is exceeded then the channel will enter a flow control state until the bandwidth usage drops below the lo threshold. To disable bandwidth controls set the high register to 0xffff, and the lower register to 0x0000.

Example:
If bandwidth sample timer has a period of 256 core clock cycles the maximum number of bytes transmitted is 256 * 8bytes = 2048bytes (64 bit architecture in the core). If the hi register is set for 1536 this means a bandwidth which is greater than 1536/2048 =75% of the maximum bandwidth (10G with a clock of 6.4ns) will force the channel into a flow control condition. If the lower threshold is 1434 then the ratio is 1434/2048 which is approximately = 0.70 or 70% of the maximum bandwidth. When the bandwidth drops below this value then the flow control condition will be disabled.

*Note the bandwidth is the ratio of the number of bytes transmitted during a sample period divided by the maximum number of bytes which could be transmitted during the same period. 
</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>hi</spirit:name>
                        <spirit:description>Sets the upper limit on the bandwidth operating range. This is used to limit the channels bandwidth consumption. Values of bandwidth which exceed this value will cause the transmit flow control mechanism for this channel to be asserted.</spirit:description>
                        <spirit:bitOffset>16</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>lo</spirit:name>
                        <spirit:description>Sets the lower limit on the bandwidth operating range. This is used to limit the channels bandwidth consumption. Values of bandwidth which drop below this value will cause the transmit flow control mechanism for this channel to be de-asserted.</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003E44</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003E38</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : control0  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                  <spirit:name>stats0</spirit:name>
                  <spirit:description>All the Statistic Registers and their configuration for the Write Engine</spirit:description>
                  <spirit:addressOffset>0x10</spirit:addressOffset>
                  <spirit:range>0x34</spirit:range>            
                  <spirit:register>
                     <spirit:name>rd2clr_config</spirit:name>
                     <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>bandwidth</spirit:name>
                        <spirit:bitOffset>11</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>dp_grd_max_err</spirit:name>
                        <spirit:bitOffset>10</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>dp_grd_eop_err</spirit:name>
                        <spirit:bitOffset>9</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>dp_grd_no_sop_err</spirit:name>
                        <spirit:bitOffset>8</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>dp_fifo_pkt_max_err</spirit:name>
                        <spirit:bitOffset>7</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>dp_fifo_fifo_full_err</spirit:name>
                        <spirit:bitOffset>6</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>dp_fifo_wr_pkt_err</spirit:name>
                        <spirit:bitOffset>5</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>dp_fifo_wr_drp_pkt</spirit:name>
                        <spirit:bitOffset>4</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>dp_fifo_rd_drp_pkt</spirit:name>
                        <spirit:bitOffset>3</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>dp_nfifo</spirit:name>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>dp_pfifo</spirit:name>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>cmd_fifo</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003E48</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>cmd_fifo</spirit:name>
                     <spirit:description>TX Command FIFO - This FIFO contains link commands (derived from link protocol responses/actions)</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003E4C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>dp_pfifo</spirit:name>
                     <spirit:description>Packet FIFO level. This represents the data for all the packets held in the FIFO subsystem.</spirit:description>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003E50</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>dp_nfifo</spirit:name>
                     <spirit:description>Notification FIFO level. This represents the number of packets in the FIFO subsystem.</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003E54</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>dp_fifo_rd_drp_pkt</spirit:name>
                     <spirit:description>Indicates the number of times a packet has been dropped at the read side of the receive FIFO.</spirit:description>
                     <spirit:addressOffset>0x10</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003E58</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>dp_fifo_wr_drp_pkt</spirit:name>
                     <spirit:description>The write side of the FIFO has dropped the application packet</spirit:description>
                     <spirit:addressOffset>0x14</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003E5C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>dp_fifo_wr_pkt_err</spirit:name>
                     <spirit:description>Indicates the packet was written into the FIFO which was received with the error flag set during the notify condition.</spirit:description>
                     <spirit:addressOffset>0x18</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003E60</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>dp_fifo_fifo_full_err</spirit:name>
                     <spirit:description>When flow control is disabled this indicates that the FIFO had reached its full point. If this happens during a packet it will be truncated and the error flag asserted with the EOP flag.</spirit:description>
                     <spirit:addressOffset>0x1C</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003E64</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>dp_fifo_pkt_max_err</spirit:name>
                     <spirit:addressOffset>0x20</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003E68</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>dp_grd_no_sop_err</spirit:name>
                     <spirit:description>This Error indicates that MCUP data after and EOP is being transmitted.</spirit:description>
                     <spirit:addressOffset>0x24</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003E6C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>dp_grd_no_eop_err</spirit:name>
                     <spirit:description>This error indicates that there was an EOP missing between two SOP's.</spirit:description>
                     <spirit:addressOffset>0x28</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003E70</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>dp_grd_max_err</spirit:name>
                     <spirit:description>This error indicates that the MCUP exceeded the maximum MCUP packet size (i.e. 64bytes).</spirit:description>
                     <spirit:addressOffset>0x2C</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003E74</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>bandwidth</spirit:name>
                     <spirit:description>This register reports the high level watermark of the channels bandwidth.</spirit:description>
                     <spirit:addressOffset>0x30</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003E78</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003E48</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 
<spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80003E38</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : tx  --> 

  <!-- reg group
                    :rx  --> 
          <spirit:registerFile>
               <spirit:name>rx</spirit:name>
               <spirit:addressOffset>0x7C</spirit:addressOffset>
               <spirit:range>0x3C</spirit:range>
  <!-- reg group
                    :control0  --> 
          <spirit:registerFile>
                  <spirit:name>control0</spirit:name>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:range>0x10</spirit:range>            
                  <spirit:register>
                     <spirit:name>dp</spirit:name>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>hys_en</spirit:name>
                        <spirit:description>Enables a hysteresis flag to operate based on the write side FIFO count.</spirit:description>
                        <spirit:bitOffset>5</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>min_lvl_mode</spirit:name>
                        <spirit:description>When in this mode the FIFO will not indicate there is data in the FIFO until the minimum level of data or EOP is written into the FIFO. The FIFO will continue to transmit until the FIFO is emptied at which point it will not start transmitting again until the FIFO has been filled back up to the minimum level again.</spirit:description>
                        <spirit:bitOffset>4</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>drp_on_pkt_err</spirit:name>
                        <spirit:description>If a packet error is received during the notification point this bit will cause the FIFO to drop the packet at the read engine.</spirit:description>
                        <spirit:bitOffset>3</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>drp_on_sop</spirit:name>
                        <spirit:description>Prevents all application packets from being written into the FIFO.</spirit:description>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>pkt_strm</spirit:name>
                        <spirit:description>1-packet mode. The data is not provided to the destination until the EOP is written into the FIFO
0-Streaming mode. The data is not provided to the destination until the ntfy_mode register value (in bytes) has been written into the FIFO</spirit:description>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003E7C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>ntfy_mode</spirit:name>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>lmt</spirit:name>
                        <spirit:description>Depending on the mode of the FIFO two options can be set.
Minimum level mode (number of FIFO words)
Packet/Streaming mode (number of BYTES)
The two modes cannot operate at the same time so this register is used for both controls.</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003E80</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>hys_lo</spirit:name>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>lvl</spirit:name>
                        <spirit:description>Sets the lower FIFO level at which the hysteresis will be cleared. This value is based on FIFO words and not bytes.</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003E84</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>hys_hi</spirit:name>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>lvl</spirit:name>
                        <spirit:description>Sets the upper FIFO level at which the hysteresis will be set. This value is based on FIFO words and not bytes.</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003E88</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003E7C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : control0  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                  <spirit:name>stats0</spirit:name>
                  <spirit:description>All the Statistic Registers and their configuration for the Write Engine</spirit:description>
                  <spirit:addressOffset>0x10</spirit:addressOffset>
                  <spirit:range>0x2C</spirit:range>            
                  <spirit:register>
                     <spirit:name>rd2clr_config</spirit:name>
                     <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>dp_grd_max_err</spirit:name>
                        <spirit:bitOffset>10</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>dp_grd_eop_err</spirit:name>
                        <spirit:bitOffset>9</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>dp_grd_no_sop_err</spirit:name>
                        <spirit:bitOffset>8</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>dp_fifo_pkt_max_err</spirit:name>
                        <spirit:bitOffset>7</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>dp_fifo_fifo_full_err</spirit:name>
                        <spirit:bitOffset>6</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>dp_fifo_wr_pkt_err</spirit:name>
                        <spirit:bitOffset>5</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>dp_fifo_wr_drp_pkt_wr</spirit:name>
                        <spirit:bitOffset>4</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>dp_fifo_rd_drp_pkt</spirit:name>
                        <spirit:bitOffset>3</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>dp_nfifo</spirit:name>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>dp_pfifo</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003E8C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>dp_pfifo</spirit:name>
                     <spirit:description>Packet FIFO level. This represents the data for all the packets held in the FIFO subsystem.</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003E90</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>dp_nfifo</spirit:name>
                     <spirit:description>Notification FIFO level. This represents the number of packets in the FIFO subsystem.</spirit:description>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003E94</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>dp_fifo_rd_drp_pkt</spirit:name>
                     <spirit:description>Indicates the number of times a packet has been dropped at the read side of the receive FIFO.</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003E98</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>dp_fifo_wr_drp_pkt</spirit:name>
                     <spirit:description>The write side of the FIFO has dropped the application packet</spirit:description>
                     <spirit:addressOffset>0x10</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003E9C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>dp_fifo_wr_pkt_err</spirit:name>
                     <spirit:description>Indicates the packet was written into the FIFO which was received with the error flag set during the notify condition.</spirit:description>
                     <spirit:addressOffset>0x14</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003EA0</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>dp_fifo_fifo_full_err</spirit:name>
                     <spirit:description>When flow control is disabled this indicates that the FIFO had reached its full point. If this happens during a packet it will be truncated and the error flag asserted with the EOP flag.</spirit:description>
                     <spirit:addressOffset>0x18</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003EA4</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>dp_fifo_pkt_max_err</spirit:name>
                     <spirit:description>Indicates that the max size packet was written into the FIFO.</spirit:description>
                     <spirit:addressOffset>0x1C</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003EA8</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>dp_grd_no_sop_err</spirit:name>
                     <spirit:description>This Error indicates that MCUP data after and EOP is being transmitted.</spirit:description>
                     <spirit:addressOffset>0x20</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003EAC</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>dp_grd_no_eop_err</spirit:name>
                     <spirit:description>This error indicates that there was an EOP missing between two SOP's.</spirit:description>
                     <spirit:addressOffset>0x24</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003EB0</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>dp_grd_max_err</spirit:name>
                     <spirit:description>This error indicates that the MCUP exceeded the maximum MCUP packet size (i.e. 64bytes).</spirit:description>
                     <spirit:addressOffset>0x28</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>cnt</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003EB4</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003E8C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 
<spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80003E7C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : rx  --> 

  <!-- reg group
                    :irq0  --> 
          <spirit:registerFile>
               <spirit:name>irq0</spirit:name>
               <spirit:description>MCA channel interrupts</spirit:description>
               <spirit:addressOffset>0xB8</spirit:addressOffset>
               <spirit:range>0x10</spirit:range>            
               <spirit:register>
                  <spirit:name>enable</spirit:name>
                  <spirit:description>Interrupt Enable register - Write 1 to enable, 0 to mask an interrupt
</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>latency_measurement</spirit:name>
                     <spirit:bitOffset>20</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_rx_fifo_wr_flow_ctrl</spirit:name>
                     <spirit:bitOffset>19</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_rx_grd_max_err</spirit:name>
                     <spirit:bitOffset>18</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_rx_grd_no_eop_err</spirit:name>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_rx_grd_no_sop_err</spirit:name>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_rx_fifo_full_err</spirit:name>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_tx_grd_max_err</spirit:name>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_tx_grd_no_eop_err</spirit:name>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_tx_grd_no_sop_err</spirit:name>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_tx_cmd_fifo_full_err</spirit:name>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_tx_fifo_full_err</spirit:name>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ltssm_rec_idl</spirit:name>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ltssm_rec_act</spirit:name>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ltssm_u0</spirit:name>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ltssm_pol_idl</spirit:name>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ltssm_pol_act</spirit:name>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ltssm_dis</spirit:name>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ltssm_inact</spirit:name>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_ready</spirit:name>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_rx_ready</spirit:name>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_tx_ready</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003EB8</address>
                        <intr.enable>irq0_mca_channel</intr.enable>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending</spirit:name>
                  <spirit:description>Interrupt Pending register - This indicates which enabled interrupts source been occurred. Only generates an interrupt when the corresponding enable bit is set. Write 1 to clear.
</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>latency_measurement</spirit:name>
                     <spirit:description>Edge-triggered - Rising Edge</spirit:description>
                     <spirit:bitOffset>20</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_rx_fifo_wr_flow_ctrl</spirit:name>
                     <spirit:description>Edge-triggered - Rising Edge</spirit:description>
                     <spirit:bitOffset>19</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_rx_grd_max_err</spirit:name>
                     <spirit:description>Edge-triggered - Rising Edge</spirit:description>
                     <spirit:bitOffset>18</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_rx_grd_no_eop_err</spirit:name>
                     <spirit:description>Edge-triggered - Rising Edge</spirit:description>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_rx_grd_no_sop_err</spirit:name>
                     <spirit:description>Edge-triggered - Rising Edge</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_rx_fifo_full_err</spirit:name>
                     <spirit:description>Edge-triggered - Rising Edge</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_tx_grd_max_err</spirit:name>
                     <spirit:description>Edge-triggered - Rising Edge</spirit:description>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_tx_grd_no_eop_err</spirit:name>
                     <spirit:description>Edge-triggered - Rising Edge</spirit:description>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_tx_grd_no_sop_err</spirit:name>
                     <spirit:description>Edge-triggered - Rising Edge</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_tx_cmd_fifo_full_err</spirit:name>
                     <spirit:description>Edge-triggered - Rising Edge</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_tx_fifo_full_err</spirit:name>
                     <spirit:description>Edge-triggered - Rising Edge</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ltssm_rec_idl</spirit:name>
                     <spirit:description>Edge-triggered - Rising Edge</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ltssm_rec_act</spirit:name>
                     <spirit:description>Edge-triggered - Rising Edge</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ltssm_u0</spirit:name>
                     <spirit:description>Edge-triggered - Rising Edge</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ltssm_pol_idl</spirit:name>
                     <spirit:description>Edge-triggered - Rising Edge</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ltssm_pol_act</spirit:name>
                     <spirit:description>Edge-triggered - Rising Edge</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ltssm_dis</spirit:name>
                     <spirit:description>Edge-triggered - Rising Edge</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ltssm_inact</spirit:name>
                     <spirit:description>Edge-triggered - Rising Edge</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_ready</spirit:name>
                     <spirit:description>Edge-triggered - Rising and Falling Edge</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_rx_ready</spirit:name>
                     <spirit:description>Edge-triggered - Rising and Falling Edge</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_tx_ready</spirit:name>
                     <spirit:description>Edge-triggered - Rising and Falling Edge</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003EBC</address>
                        <intr.status>irq0_mca_channel</intr.status>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending_irq</spirit:name>
                  <spirit:description>Interrupt Pending register - This indicates which enabled interrupts have been triggered, Write 1 to clear
</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>latency_measurement</spirit:name>
                     <spirit:description>Edge-triggered - Rising Edge</spirit:description>
                     <spirit:bitOffset>20</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_rx_fifo_wr_flow_ctrl</spirit:name>
                     <spirit:description>Edge-triggered - Rising Edge</spirit:description>
                     <spirit:bitOffset>19</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_rx_grd_max_err</spirit:name>
                     <spirit:description>Edge-triggered - Rising Edge</spirit:description>
                     <spirit:bitOffset>18</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_rx_grd_no_eop_err</spirit:name>
                     <spirit:description>Edge-triggered - Rising Edge</spirit:description>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_rx_grd_no_sop_err</spirit:name>
                     <spirit:description>Edge-triggered - Rising Edge</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_rx_fifo_full_err</spirit:name>
                     <spirit:description>Edge-triggered - Rising Edge</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_tx_grd_max_err</spirit:name>
                     <spirit:description>Edge-triggered - Rising Edge</spirit:description>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_tx_grd_no_eop_err</spirit:name>
                     <spirit:description>Edge-triggered - Rising Edge</spirit:description>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_tx_grd_no_sop_err</spirit:name>
                     <spirit:description>Edge-triggered - Rising Edge</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_tx_cmd_fifo_full_err</spirit:name>
                     <spirit:description>Edge-triggered - Rising Edge</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_tx_fifo_full_err</spirit:name>
                     <spirit:description>Edge-triggered - Rising Edge</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ltssm_rec_idl</spirit:name>
                     <spirit:description>Edge-triggered - Rising Edge</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ltssm_rec_act</spirit:name>
                     <spirit:description>Edge-triggered - Rising Edge</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ltssm_u0</spirit:name>
                     <spirit:description>Edge-triggered - Rising Edge</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ltssm_pol_idl</spirit:name>
                     <spirit:description>Edge-triggered - Rising Edge</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ltssm_pol_act</spirit:name>
                     <spirit:description>Edge-triggered - Rising Edge</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ltssm_dis</spirit:name>
                     <spirit:description>Edge-triggered - Rising Edge</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ltssm_inact</spirit:name>
                     <spirit:description>Edge-triggered - Rising Edge</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_ready</spirit:name>
                     <spirit:description>Edge-triggered - Rising and Falling Edge</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_rx_ready</spirit:name>
                     <spirit:description>Edge-triggered - Rising and Falling Edge</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_tx_ready</spirit:name>
                     <spirit:description>Edge-triggered - Rising and Falling Edge</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003EC0</address>
                        <intr.pending>irq0_mca_channel</intr.pending>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>raw</spirit:name>
                  <spirit:description>This register contains the active state of interrupt sources</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>latency_measurement</spirit:name>
                     <spirit:description>(Pulsed high) - Test Information ready</spirit:description>
                     <spirit:bitOffset>20</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_rx_fifo_wr_flow_ctrl</spirit:name>
                     <spirit:description>(Active-High) - critical information</spirit:description>
                     <spirit:bitOffset>19</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_rx_grd_max_err</spirit:name>
                     <spirit:description>(Pulsed High) - critical information</spirit:description>
                     <spirit:bitOffset>18</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_rx_grd_no_eop_err</spirit:name>
                     <spirit:description>(Pulsed High) - critical information</spirit:description>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_rx_grd_no_sop_err</spirit:name>
                     <spirit:description>(Pulsed High) - critical information</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_rx_fifo_full_err</spirit:name>
                     <spirit:description>(Pulsed High) - critical information</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_tx_grd_max_err</spirit:name>
                     <spirit:description>(Pulsed High) - critical information</spirit:description>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_tx_grd_no_eop_err</spirit:name>
                     <spirit:description>(Pulsed High) - critical information</spirit:description>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_tx_grd_no_sop_err</spirit:name>
                     <spirit:description>(Pulsed High) - critical information</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_tx_cmd_fifo_full_err</spirit:name>
                     <spirit:description>(Pulsed High) - critical information</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_tx_fifo_full_err</spirit:name>
                     <spirit:description>(Pulsed High) - critical information</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ltssm_rec_idl</spirit:name>
                     <spirit:description>(Active-High) - Status Information</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ltssm_rec_act</spirit:name>
                     <spirit:description>(Active-High) - Status Information</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ltssm_u0</spirit:name>
                     <spirit:description>(Active-High) - Status Information</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ltssm_pol_idl</spirit:name>
                     <spirit:description>(Active-High) - Status Information</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ltssm_pol_act</spirit:name>
                     <spirit:description>(Active-High) - Status Information</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ltssm_dis</spirit:name>
                     <spirit:description>(Active-High) - Status Information</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ltssm_inact</spirit:name>
                     <spirit:description>(Active-High) - Status Information</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_ready</spirit:name>
                     <spirit:description>(Active-High) - Status Information</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_rx_ready</spirit:name>
                     <spirit:description>(Active-High) - Status Information</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ch_tx_ready</spirit:name>
                     <spirit:description>(Active-High) - Status Information</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003EC4</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80003EB8</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : irq0  --> 

  <!-- reg group
                    :test_mode  --> 
          <spirit:registerFile>
               <spirit:name>test_mode</spirit:name>
               <spirit:addressOffset>0xC8</spirit:addressOffset>
               <spirit:range>0x38</spirit:range>
  <!-- reg group
                    :tx  --> 
          <spirit:registerFile>
                  <spirit:name>tx</spirit:name>
                  <spirit:description>Registers needed for the Media Generator needed for self-test</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:range>0x24</spirit:range>            
                  <spirit:register>
                     <spirit:name>version</spirit:name>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:reset>
                        <spirit:value>0x00020000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>major</spirit:name>
                        <spirit:description>Major version</spirit:description>
                        <spirit:bitOffset>16</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000010</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>minor</spirit:name>
                        <spirit:description>Minor version</spirit:description>
                        <spirit:bitOffset>8</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>patch</spirit:name>
                        <spirit:description>Patch version</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003EC8</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
  <!-- reg group
                    :config0  --> 
          <spirit:registerFile>
                     <spirit:name>config0</spirit:name>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:range>0x14</spirit:range>            
                     <spirit:register>
                        <spirit:name>iwg_cnt</spirit:name>
                        <spirit:description>inter word gap count</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>setting</spirit:name>
                           <spirit:description>Media generator inter-word gap count. This is the number of srdy "not ready" (srdy = 1'b0) cycles that can be inserted between words.

0 = 0 cycles
1 = 1 cycle
2 = 2 cycles
ect..
</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>11</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80003ECC</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>ifg_cnt</spirit:name>
                        <spirit:description>inter frame gap count</spirit:description>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000001</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>setting</spirit:name>
                           <spirit:description>Media generator inter-frame gap count. This is the number of clock cycles that can be inserted between packets.

0 = 0 cycles
1 = 1 cycle
2 = 2 cycles
ect..</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>11</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000001</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80003ED0</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pkt_cnt</spirit:name>
                        <spirit:description>number of packets to send</spirit:description>
                        <spirit:addressOffset>0x8</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x0000000A</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>setting</spirit:name>
                           <spirit:description>Media generator packet count select.

Set to "0" for continuous transmission mode.
</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>11</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000001010</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80003ED4</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pkt_size</spirit:name>
                        <spirit:description>packet length size in number of bytes</spirit:description>
                        <spirit:addressOffset>0xC</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000001</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>setting</spirit:name>
                           <spirit:description>Media generator packet length size in number of bytes</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>11</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000001</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80003ED8</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>ctrl0</spirit:name>
                        <spirit:description>Media generator configuration register</spirit:description>
                        <spirit:addressOffset>0x10</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>random</spirit:name>
                           <spirit:description>Randomization of the following register control setting (internally driven)

iwg_cnt
ifg_cnt
pkt_size

0 = disabled</spirit:description>
                           <spirit:bitOffset>4</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>throttle</spirit:name>
                           <spirit:description>Media generator throttle enable. Allows CPU to control media generator transmitter source ready (srdy).

0 = srdy with/without drdy (may cause loss of traffic)
1 = srdy with drdy</spirit:description>
                           <spirit:bitOffset>3</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>mode</spirit:name>
                           <spirit:description>Media generator "data" traffic mode select. 

0 = incrementing data
1 = random data</spirit:description>
                           <spirit:bitOffset>2</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>enable</spirit:name>
                           <spirit:description>Media generator enable. Must be set '0' if the corresponding media is trying to connect to the pipe. Can also be set '0' to stop a media generator that is set for continuous transmission mode. Actual transmission will not start until the go bit is hit (ie: first enable then hit go bit).

0 = disabled
1 = enabled</spirit:description>
                           <spirit:bitOffset>1</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>go</spirit:name>
                           <spirit:description>Go/Busy (Cleared by HW)
write:
0 = disabled
1 = start of test
read:
0 = test complete
1 = test is running

</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                              <ids_properties>
                                 <rtl.hw_clear>1</rtl.hw_clear>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80003EDC</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003ECC</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : config0  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                     <spirit:name>stats0</spirit:name>
                     <spirit:description>All the Statistic Registers and their configuration for the mgen_tx</spirit:description>
                     <spirit:addressOffset>0x18</spirit:addressOffset>
                     <spirit:range>0xC</spirit:range>            
                     <spirit:register>
                        <spirit:name>rd2clr_config</spirit:name>
                        <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>wait_count</spirit:name>
                           <spirit:bitOffset>1</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pkt_count</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80003EE0</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>wait_count</spirit:name>
                        <spirit:description>Transmit wait count of destination not ready (drdy)</spirit:description>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>wait_count</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>32</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000000000000000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80003EE4</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pkt_count</spirit:name>
                        <spirit:description>Transmit packet count</spirit:description>
                        <spirit:addressOffset>0x8</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>pkt_count</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>32</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000000000000000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80003EE8</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003EE0</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 
<spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003EC8</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : tx  --> 

  <!-- reg group
                    :rx  --> 
          <spirit:registerFile>
                  <spirit:name>rx</spirit:name>
                  <spirit:description>Registers needed for the Media Generator needed for self-test</spirit:description>
                  <spirit:addressOffset>0x24</spirit:addressOffset>
                  <spirit:range>0x14</spirit:range>            
                  <spirit:register>
                     <spirit:name>version</spirit:name>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:reset>
                        <spirit:value>0x00010000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>major</spirit:name>
                        <spirit:description>Major version</spirit:description>
                        <spirit:bitOffset>16</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000001</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>minor</spirit:name>
                        <spirit:description>Minor version</spirit:description>
                        <spirit:bitOffset>8</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>patch</spirit:name>
                        <spirit:description>Patch version</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003EEC</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
  <!-- reg group
                    :config0  --> 
          <spirit:registerFile>
                     <spirit:name>config0</spirit:name>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:range>0x4</spirit:range>            
                     <spirit:register>
                        <spirit:name>mgen</spirit:name>
                        <spirit:description>Media generator configuration register</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000008</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>en_rxflw</spirit:name>
                           <spirit:description>Receiver drdy ready (flow control)

0 = drdy receiver not ready
1 = drdy receiver ready</spirit:description>
                           <spirit:bitOffset>3</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>1</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>mode</spirit:name>
                           <spirit:description>Media generator traffic mode select. 

0 = incrementing data
1 = random data</spirit:description>
                           <spirit:bitOffset>2</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>enable</spirit:name>
                           <spirit:description>Media generator enable. Must be set '0' if the corresponding media is trying to connect to the pipe. Can also be set '0' to stop a media generator that is set for continuous mode. Set '1' if setting go '1'.

0 = disabled
1 = enabled</spirit:description>
                           <spirit:bitOffset>1</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>go</spirit:name>
                           <spirit:description>*Not implemented (expected possible future use)*
Go/Busy (Cleared by HW)
</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                              <ids_properties>
                                 <rtl.hw_clear>1</rtl.hw_clear>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80003EF0</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003EF0</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : config0  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                     <spirit:name>stats0</spirit:name>
                     <spirit:description>All the Statistic Registers and their configuration for the mgen_rx</spirit:description>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:range>0xC</spirit:range>            
                     <spirit:register>
                        <spirit:name>rd2clr_config</spirit:name>
                        <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>err_count</spirit:name>
                           <spirit:bitOffset>1</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pkt_count</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
