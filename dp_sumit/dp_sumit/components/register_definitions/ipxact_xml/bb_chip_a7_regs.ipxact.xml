                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>ntfy_lmt</spirit:name>
                           <spirit:description>Sets the number of words required to be written into the packet FIFO before a notification will be generated. See wiki</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>32</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000000000000000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80004EB8</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004EB0</address>
                           <context>iso_lex_fifo_1_write_engine</context>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : config0  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                     <spirit:name>stats0</spirit:name>
                     <spirit:description>All the Statistic Registers and their configuration for the Write Engine</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:range>0x2C</spirit:range>            
                     <spirit:register>
                        <spirit:name>rd2clr_config</spirit:name>
                        <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:bitOffset>9</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>drp_pkt_wr</spirit:name>
                           <spirit:bitOffset>8</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>drp_pkt_rd</spirit:name>
                           <spirit:bitOffset>7</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>wflush_act</spirit:name>
                           <spirit:bitOffset>6</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pkt_sop_err</spirit:name>
                           <spirit:bitOffset>5</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pkt_err</spirit:name>
                           <spirit:bitOffset>4</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>fifo_full_err</spirit:name>
                           <spirit:bitOffset>3</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pkt_max_byte_cnt_err</spirit:name>
                           <spirit:bitOffset>2</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pfifo_dcount</spirit:name>
                           <spirit:bitOffset>1</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>nfifo_dcount</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004EBC</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>nfifo_dcount</spirit:name>
                        <spirit:description>Current level for the notification FIFO in the PFIFO</spirit:description>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>nfifo_dcount</spirit:name>
                           <spirit:description>_icron_water_marker_
_icron_no_counter_</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004EC0</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pfifo_dcount</spirit:name>
                        <spirit:description>Current level for the packet FIFO in the PFIFO</spirit:description>
                        <spirit:addressOffset>0x8</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>pfifo_dcount</spirit:name>
                           <spirit:description>_icron_water_marker_
_icron_no_counter_</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004EC4</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pkt_max_byte_cnt_err</spirit:name>
                        <spirit:description>The count for capped packets in PFIFO write engine, as the result of reaching maximum size in the PFIFO</spirit:description>
                        <spirit:addressOffset>0xC</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>pkt_max_byte_cnt_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004EC8</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>fifo_full_err</spirit:name>
                        <spirit:description>The count for either of PFIFO or NFIFO being full</spirit:description>
                        <spirit:addressOffset>0x10</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>fifo_full_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004ECC</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pkt_err</spirit:name>
                        <spirit:description>The count of packets tagged to be dropped later in the PFIFO read engine</spirit:description>
                        <spirit:addressOffset>0x14</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>pkt_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004ED0</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pkt_sop_err</spirit:name>
                        <spirit:description>The count of packets flushed in the PFIFO during the SOP phase</spirit:description>
                        <spirit:addressOffset>0x18</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>pkt_sop_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004ED4</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>wflush_act</spirit:name>
                        <spirit:description>The count of capped packets in the PFIFO. Note that back-to-back packets are counted as one if they are both capped.</spirit:description>
                        <spirit:addressOffset>0x1C</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>wflush_act</spirit:name>
                           <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004ED8</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>drp_pkt_rd</spirit:name>
                        <spirit:description>The count of drop packets flagged to be dropped by the read engine</spirit:description>
                        <spirit:addressOffset>0x20</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>drp_pkt_rd</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004EDC</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>drp_pkt_wr</spirit:name>
                        <spirit:description>The count of drop packets by the write engine</spirit:description>
                        <spirit:addressOffset>0x24</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>drp_pkt_wr</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004EE0</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>flow_ctrl</spirit:name>
                        <spirit:description>The count of the clock cycles the DRDY is asserted low resulting in flow control</spirit:description>
                        <spirit:addressOffset>0x28</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004EE4</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004EBC</address>
                           <context>iso_lex_fifo_1_write_engine</context>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 
<spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004EB0</address>
                        <context>iso_lex_fifo_1</context>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : write_engine  --> 

  <!-- reg group
                    :read_engine  --> 
          <spirit:registerFile>
                  <spirit:name>read_engine</spirit:name>
                  <spirit:addressOffset>0x3C</spirit:addressOffset>
                  <spirit:range>0x14</spirit:range>
  <!-- reg group
                    :config0  --> 
          <spirit:registerFile>
                     <spirit:name>config0</spirit:name>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:range>0x4</spirit:range>            
                     <spirit:register>
                        <spirit:name>clear</spirit:name>
                        <spirit:description>Synchronous clear for the read clock domain</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>rclr</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80004EE8</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004EE8</address>
                           <context>iso_lex_fifo_1_read_engine</context>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : config0  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                     <spirit:name>stats0</spirit:name>
                     <spirit:description>All the Statistic Registers and their configuration for the Read Engine</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:range>0x10</spirit:range>            
                     <spirit:register>
                        <spirit:name>rd2clr_config</spirit:name>
                        <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:bitOffset>2</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>drp_pkt</spirit:name>
                           <spirit:bitOffset>1</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>rflush_act</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004EEC</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>rflush_act</spirit:name>
                        <spirit:description>The counts of number of packets flushed from the PFIFO.</spirit:description>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>rflush_act</spirit:name>
                           <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004EF0</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>drp_pkt</spirit:name>
                        <spirit:description>The counts of drop packet in the PFIFO read engine</spirit:description>
                        <spirit:addressOffset>0x8</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>drp_pkt</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004EF4</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>flow_ctrl</spirit:name>
                        <spirit:description>The count of the clock cycles the DRDY is asserted low resulting in flow control</spirit:description>
                        <spirit:addressOffset>0xC</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004EF8</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004EEC</address>
                           <context>iso_lex_fifo_1_read_engine</context>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 
<spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004EE8</address>
                        <context>iso_lex_fifo_1</context>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : read_engine  --> 
<spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004EAC</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : iso_lex_fifo_1  --> 

  <!-- reg group
                    :iso_lex_fifo_2  --> 
          <spirit:registerFile>
               <spirit:name>iso_lex_fifo_2</spirit:name>
               <spirit:addressOffset>0xFC</spirit:addressOffset>
               <spirit:range>0x50</spirit:range>            
               <spirit:register>
                  <spirit:name>version</spirit:name>
                  <spirit:description>Version 1.1.0: Added Icron Attributes for stats script generation</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00010100</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>major</spirit:name>
                     <spirit:description>Major version</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000001</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>minor</spirit:name>
                     <spirit:description>Minor version</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000001</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>patch</spirit:name>
                     <spirit:description>Patch version</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004EFC</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
  <!-- reg group
                    :write_engine  --> 
          <spirit:registerFile>
                  <spirit:name>write_engine</spirit:name>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:range>0x38</spirit:range>
  <!-- reg group
                    :config0  --> 
          <spirit:registerFile>
                     <spirit:name>config0</spirit:name>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:range>0xC</spirit:range>            
                     <spirit:register>
                        <spirit:name>clear</spirit:name>
                        <spirit:description>Synchronous clear for the write clock domain</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>wclr</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80004F00</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>mode</spirit:name>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000005</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>drp_on_sop</spirit:name>
                           <spirit:description>When set, drops the current packet without writing it to the buffer. See Wiki</spirit:description>
                           <spirit:bitOffset>3</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>drp_on_pkt_err</spirit:name>
                           <spirit:description>When set, removes the packet from the buffer without presenting it to the output interface upon the ERR bit being set before the notification point. See Wiki</spirit:description>
                           <spirit:bitOffset>2</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>1</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pkt_strm</spirit:name>
                           <spirit:description>Selects packet based or streaming based behavior. See Wiki</spirit:description>
                           <spirit:bitOffset>1</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>flw_ctrl_en</spirit:name>
                           <spirit:description>Enables the flow control. See Wiki</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>1</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80004F04</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>notify_limit</spirit:name>
                        <spirit:addressOffset>0x8</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>ntfy_lmt</spirit:name>
                           <spirit:description>Sets the number of words required to be written into the packet FIFO before a notification will be generated. See wiki</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>32</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000000000000000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80004F08</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004F00</address>
                           <context>iso_lex_fifo_2_write_engine</context>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : config0  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                     <spirit:name>stats0</spirit:name>
                     <spirit:description>All the Statistic Registers and their configuration for the Write Engine</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:range>0x2C</spirit:range>            
                     <spirit:register>
                        <spirit:name>rd2clr_config</spirit:name>
                        <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:bitOffset>9</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>drp_pkt_wr</spirit:name>
                           <spirit:bitOffset>8</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>drp_pkt_rd</spirit:name>
                           <spirit:bitOffset>7</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>wflush_act</spirit:name>
                           <spirit:bitOffset>6</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pkt_sop_err</spirit:name>
                           <spirit:bitOffset>5</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pkt_err</spirit:name>
                           <spirit:bitOffset>4</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>fifo_full_err</spirit:name>
                           <spirit:bitOffset>3</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pkt_max_byte_cnt_err</spirit:name>
                           <spirit:bitOffset>2</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pfifo_dcount</spirit:name>
                           <spirit:bitOffset>1</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>nfifo_dcount</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004F0C</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>nfifo_dcount</spirit:name>
                        <spirit:description>Current level for the notification FIFO in the PFIFO</spirit:description>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>nfifo_dcount</spirit:name>
                           <spirit:description>_icron_water_marker_
_icron_no_counter_</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004F10</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pfifo_dcount</spirit:name>
                        <spirit:description>Current level for the packet FIFO in the PFIFO</spirit:description>
                        <spirit:addressOffset>0x8</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>pfifo_dcount</spirit:name>
                           <spirit:description>_icron_water_marker_
_icron_no_counter_</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004F14</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pkt_max_byte_cnt_err</spirit:name>
                        <spirit:description>The count for capped packets in PFIFO write engine, as the result of reaching maximum size in the PFIFO</spirit:description>
                        <spirit:addressOffset>0xC</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>pkt_max_byte_cnt_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004F18</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>fifo_full_err</spirit:name>
                        <spirit:description>The count for either of PFIFO or NFIFO being full</spirit:description>
                        <spirit:addressOffset>0x10</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>fifo_full_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004F1C</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pkt_err</spirit:name>
                        <spirit:description>The count of packets tagged to be dropped later in the PFIFO read engine</spirit:description>
                        <spirit:addressOffset>0x14</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>pkt_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004F20</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pkt_sop_err</spirit:name>
                        <spirit:description>The count of packets flushed in the PFIFO during the SOP phase</spirit:description>
                        <spirit:addressOffset>0x18</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>pkt_sop_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004F24</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>wflush_act</spirit:name>
                        <spirit:description>The count of capped packets in the PFIFO. Note that back-to-back packets are counted as one if they are both capped.</spirit:description>
                        <spirit:addressOffset>0x1C</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>wflush_act</spirit:name>
                           <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004F28</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>drp_pkt_rd</spirit:name>
                        <spirit:description>The count of drop packets flagged to be dropped by the read engine</spirit:description>
                        <spirit:addressOffset>0x20</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>drp_pkt_rd</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004F2C</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>drp_pkt_wr</spirit:name>
                        <spirit:description>The count of drop packets by the write engine</spirit:description>
                        <spirit:addressOffset>0x24</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>drp_pkt_wr</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004F30</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>flow_ctrl</spirit:name>
                        <spirit:description>The count of the clock cycles the DRDY is asserted low resulting in flow control</spirit:description>
                        <spirit:addressOffset>0x28</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004F34</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004F0C</address>
                           <context>iso_lex_fifo_2_write_engine</context>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 
<spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004F00</address>
                        <context>iso_lex_fifo_2</context>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : write_engine  --> 

  <!-- reg group
                    :read_engine  --> 
          <spirit:registerFile>
                  <spirit:name>read_engine</spirit:name>
                  <spirit:addressOffset>0x3C</spirit:addressOffset>
                  <spirit:range>0x14</spirit:range>
  <!-- reg group
                    :config0  --> 
          <spirit:registerFile>
                     <spirit:name>config0</spirit:name>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:range>0x4</spirit:range>            
                     <spirit:register>
                        <spirit:name>clear</spirit:name>
                        <spirit:description>Synchronous clear for the read clock domain</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>rclr</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80004F38</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004F38</address>
                           <context>iso_lex_fifo_2_read_engine</context>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : config0  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                     <spirit:name>stats0</spirit:name>
                     <spirit:description>All the Statistic Registers and their configuration for the Read Engine</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:range>0x10</spirit:range>            
                     <spirit:register>
                        <spirit:name>rd2clr_config</spirit:name>
                        <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:bitOffset>2</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>drp_pkt</spirit:name>
                           <spirit:bitOffset>1</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>rflush_act</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004F3C</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>rflush_act</spirit:name>
                        <spirit:description>The counts of number of packets flushed from the PFIFO.</spirit:description>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>rflush_act</spirit:name>
                           <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004F40</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>drp_pkt</spirit:name>
                        <spirit:description>The counts of drop packet in the PFIFO read engine</spirit:description>
                        <spirit:addressOffset>0x8</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>drp_pkt</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004F44</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>flow_ctrl</spirit:name>
                        <spirit:description>The count of the clock cycles the DRDY is asserted low resulting in flow control</spirit:description>
                        <spirit:addressOffset>0xC</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004F48</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004F3C</address>
                           <context>iso_lex_fifo_2_read_engine</context>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 
<spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004F38</address>
                        <context>iso_lex_fifo_2</context>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : read_engine  --> 
<spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004EFC</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : iso_lex_fifo_2  --> 

  <!-- reg group
                    :iso_lex_fifo_3  --> 
          <spirit:registerFile>
               <spirit:name>iso_lex_fifo_3</spirit:name>
               <spirit:addressOffset>0x14C</spirit:addressOffset>
               <spirit:range>0x50</spirit:range>            
               <spirit:register>
                  <spirit:name>version</spirit:name>
                  <spirit:description>Version 1.1.0: Added Icron Attributes for stats script generation</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00010100</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>major</spirit:name>
                     <spirit:description>Major version</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000001</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>minor</spirit:name>
                     <spirit:description>Minor version</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000001</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>patch</spirit:name>
                     <spirit:description>Patch version</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004F4C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
  <!-- reg group
                    :write_engine  --> 
          <spirit:registerFile>
                  <spirit:name>write_engine</spirit:name>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:range>0x38</spirit:range>
  <!-- reg group
                    :config0  --> 
          <spirit:registerFile>
                     <spirit:name>config0</spirit:name>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:range>0xC</spirit:range>            
                     <spirit:register>
                        <spirit:name>clear</spirit:name>
                        <spirit:description>Synchronous clear for the write clock domain</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>wclr</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80004F50</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>mode</spirit:name>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000005</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>drp_on_sop</spirit:name>
                           <spirit:description>When set, drops the current packet without writing it to the buffer. See Wiki</spirit:description>
                           <spirit:bitOffset>3</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>drp_on_pkt_err</spirit:name>
                           <spirit:description>When set, removes the packet from the buffer without presenting it to the output interface upon the ERR bit being set before the notification point. See Wiki</spirit:description>
                           <spirit:bitOffset>2</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>1</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pkt_strm</spirit:name>
                           <spirit:description>Selects packet based or streaming based behavior. See Wiki</spirit:description>
                           <spirit:bitOffset>1</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>flw_ctrl_en</spirit:name>
                           <spirit:description>Enables the flow control. See Wiki</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>1</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80004F54</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>notify_limit</spirit:name>
                        <spirit:addressOffset>0x8</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>ntfy_lmt</spirit:name>
                           <spirit:description>Sets the number of words required to be written into the packet FIFO before a notification will be generated. See wiki</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>32</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000000000000000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80004F58</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004F50</address>
                           <context>iso_lex_fifo_3_write_engine</context>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : config0  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                     <spirit:name>stats0</spirit:name>
                     <spirit:description>All the Statistic Registers and their configuration for the Write Engine</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:range>0x2C</spirit:range>            
                     <spirit:register>
                        <spirit:name>rd2clr_config</spirit:name>
                        <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:bitOffset>9</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>drp_pkt_wr</spirit:name>
                           <spirit:bitOffset>8</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>drp_pkt_rd</spirit:name>
                           <spirit:bitOffset>7</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>wflush_act</spirit:name>
                           <spirit:bitOffset>6</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pkt_sop_err</spirit:name>
                           <spirit:bitOffset>5</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pkt_err</spirit:name>
                           <spirit:bitOffset>4</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>fifo_full_err</spirit:name>
                           <spirit:bitOffset>3</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pkt_max_byte_cnt_err</spirit:name>
                           <spirit:bitOffset>2</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pfifo_dcount</spirit:name>
                           <spirit:bitOffset>1</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>nfifo_dcount</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004F5C</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>nfifo_dcount</spirit:name>
                        <spirit:description>Current level for the notification FIFO in the PFIFO</spirit:description>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>nfifo_dcount</spirit:name>
                           <spirit:description>_icron_water_marker_
_icron_no_counter_</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004F60</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pfifo_dcount</spirit:name>
                        <spirit:description>Current level for the packet FIFO in the PFIFO</spirit:description>
                        <spirit:addressOffset>0x8</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>pfifo_dcount</spirit:name>
                           <spirit:description>_icron_water_marker_
_icron_no_counter_</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004F64</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pkt_max_byte_cnt_err</spirit:name>
                        <spirit:description>The count for capped packets in PFIFO write engine, as the result of reaching maximum size in the PFIFO</spirit:description>
                        <spirit:addressOffset>0xC</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>pkt_max_byte_cnt_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004F68</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>fifo_full_err</spirit:name>
                        <spirit:description>The count for either of PFIFO or NFIFO being full</spirit:description>
                        <spirit:addressOffset>0x10</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>fifo_full_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004F6C</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pkt_err</spirit:name>
                        <spirit:description>The count of packets tagged to be dropped later in the PFIFO read engine</spirit:description>
                        <spirit:addressOffset>0x14</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>pkt_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004F70</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pkt_sop_err</spirit:name>
                        <spirit:description>The count of packets flushed in the PFIFO during the SOP phase</spirit:description>
                        <spirit:addressOffset>0x18</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>pkt_sop_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004F74</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>wflush_act</spirit:name>
                        <spirit:description>The count of capped packets in the PFIFO. Note that back-to-back packets are counted as one if they are both capped.</spirit:description>
                        <spirit:addressOffset>0x1C</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>wflush_act</spirit:name>
                           <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004F78</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>drp_pkt_rd</spirit:name>
                        <spirit:description>The count of drop packets flagged to be dropped by the read engine</spirit:description>
                        <spirit:addressOffset>0x20</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>drp_pkt_rd</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004F7C</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>drp_pkt_wr</spirit:name>
                        <spirit:description>The count of drop packets by the write engine</spirit:description>
                        <spirit:addressOffset>0x24</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>drp_pkt_wr</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004F80</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>flow_ctrl</spirit:name>
                        <spirit:description>The count of the clock cycles the DRDY is asserted low resulting in flow control</spirit:description>
                        <spirit:addressOffset>0x28</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004F84</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004F5C</address>
                           <context>iso_lex_fifo_3_write_engine</context>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 
<spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004F50</address>
                        <context>iso_lex_fifo_3</context>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : write_engine  --> 

  <!-- reg group
                    :read_engine  --> 
          <spirit:registerFile>
                  <spirit:name>read_engine</spirit:name>
                  <spirit:addressOffset>0x3C</spirit:addressOffset>
                  <spirit:range>0x14</spirit:range>
  <!-- reg group
                    :config0  --> 
          <spirit:registerFile>
                     <spirit:name>config0</spirit:name>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:range>0x4</spirit:range>            
                     <spirit:register>
                        <spirit:name>clear</spirit:name>
                        <spirit:description>Synchronous clear for the read clock domain</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>rclr</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80004F88</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004F88</address>
                           <context>iso_lex_fifo_3_read_engine</context>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : config0  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                     <spirit:name>stats0</spirit:name>
                     <spirit:description>All the Statistic Registers and their configuration for the Read Engine</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:range>0x10</spirit:range>            
                     <spirit:register>
                        <spirit:name>rd2clr_config</spirit:name>
                        <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:bitOffset>2</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>drp_pkt</spirit:name>
                           <spirit:bitOffset>1</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>rflush_act</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004F8C</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>rflush_act</spirit:name>
                        <spirit:description>The counts of number of packets flushed from the PFIFO.</spirit:description>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>rflush_act</spirit:name>
                           <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004F90</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>drp_pkt</spirit:name>
                        <spirit:description>The counts of drop packet in the PFIFO read engine</spirit:description>
                        <spirit:addressOffset>0x8</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>drp_pkt</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004F94</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>flow_ctrl</spirit:name>
                        <spirit:description>The count of the clock cycles the DRDY is asserted low resulting in flow control</spirit:description>
                        <spirit:addressOffset>0xC</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004F98</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004F8C</address>
                           <context>iso_lex_fifo_3_read_engine</context>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 
<spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004F88</address>
                        <context>iso_lex_fifo_3</context>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : read_engine  --> 
<spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004F4C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : iso_lex_fifo_3  --> 

  <!-- reg group
                    :iso_rex_fifo  --> 
          <spirit:registerFile>
               <spirit:name>iso_rex_fifo</spirit:name>
               <spirit:addressOffset>0x19C</spirit:addressOffset>
               <spirit:range>0x50</spirit:range>            
               <spirit:register>
                  <spirit:name>version</spirit:name>
                  <spirit:description>Version 1.1.0: Added Icron Attributes for stats script generation</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00010100</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>major</spirit:name>
                     <spirit:description>Major version</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000001</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>minor</spirit:name>
                     <spirit:description>Minor version</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000001</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>patch</spirit:name>
                     <spirit:description>Patch version</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004F9C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
  <!-- reg group
                    :write_engine  --> 
          <spirit:registerFile>
                  <spirit:name>write_engine</spirit:name>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:range>0x38</spirit:range>
  <!-- reg group
                    :config0  --> 
          <spirit:registerFile>
                     <spirit:name>config0</spirit:name>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:range>0xC</spirit:range>            
                     <spirit:register>
                        <spirit:name>clear</spirit:name>
                        <spirit:description>Synchronous clear for the write clock domain</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>wclr</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80004FA0</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>mode</spirit:name>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000005</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>drp_on_sop</spirit:name>
                           <spirit:description>When set, drops the current packet without writing it to the buffer. See Wiki</spirit:description>
                           <spirit:bitOffset>3</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>drp_on_pkt_err</spirit:name>
                           <spirit:description>When set, removes the packet from the buffer without presenting it to the output interface upon the ERR bit being set before the notification point. See Wiki</spirit:description>
                           <spirit:bitOffset>2</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>1</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pkt_strm</spirit:name>
                           <spirit:description>Selects packet based or streaming based behavior. See Wiki</spirit:description>
                           <spirit:bitOffset>1</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>flw_ctrl_en</spirit:name>
                           <spirit:description>Enables the flow control. See Wiki</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>1</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80004FA4</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>notify_limit</spirit:name>
                        <spirit:addressOffset>0x8</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>ntfy_lmt</spirit:name>
                           <spirit:description>Sets the number of words required to be written into the packet FIFO before a notification will be generated. See wiki</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>32</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000000000000000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80004FA8</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004FA0</address>
                           <context>iso_rex_fifo_write_engine</context>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : config0  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                     <spirit:name>stats0</spirit:name>
                     <spirit:description>All the Statistic Registers and their configuration for the Write Engine</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:range>0x2C</spirit:range>            
                     <spirit:register>
                        <spirit:name>rd2clr_config</spirit:name>
                        <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:bitOffset>9</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>drp_pkt_wr</spirit:name>
                           <spirit:bitOffset>8</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>drp_pkt_rd</spirit:name>
                           <spirit:bitOffset>7</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>wflush_act</spirit:name>
                           <spirit:bitOffset>6</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pkt_sop_err</spirit:name>
                           <spirit:bitOffset>5</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pkt_err</spirit:name>
                           <spirit:bitOffset>4</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>fifo_full_err</spirit:name>
                           <spirit:bitOffset>3</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pkt_max_byte_cnt_err</spirit:name>
                           <spirit:bitOffset>2</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pfifo_dcount</spirit:name>
                           <spirit:bitOffset>1</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>nfifo_dcount</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004FAC</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>nfifo_dcount</spirit:name>
                        <spirit:description>Current level for the notification FIFO in the PFIFO</spirit:description>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>nfifo_dcount</spirit:name>
                           <spirit:description>_icron_water_marker_
_icron_no_counter_</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004FB0</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pfifo_dcount</spirit:name>
                        <spirit:description>Current level for the packet FIFO in the PFIFO</spirit:description>
                        <spirit:addressOffset>0x8</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>pfifo_dcount</spirit:name>
                           <spirit:description>_icron_water_marker_
_icron_no_counter_</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004FB4</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pkt_max_byte_cnt_err</spirit:name>
                        <spirit:description>The count for capped packets in PFIFO write engine, as the result of reaching maximum size in the PFIFO</spirit:description>
                        <spirit:addressOffset>0xC</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>pkt_max_byte_cnt_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004FB8</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>fifo_full_err</spirit:name>
                        <spirit:description>The count for either of PFIFO or NFIFO being full</spirit:description>
                        <spirit:addressOffset>0x10</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>fifo_full_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004FBC</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pkt_err</spirit:name>
                        <spirit:description>The count of packets tagged to be dropped later in the PFIFO read engine</spirit:description>
                        <spirit:addressOffset>0x14</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>pkt_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004FC0</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pkt_sop_err</spirit:name>
                        <spirit:description>The count of packets flushed in the PFIFO during the SOP phase</spirit:description>
                        <spirit:addressOffset>0x18</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>pkt_sop_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004FC4</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>wflush_act</spirit:name>
                        <spirit:description>The count of capped packets in the PFIFO. Note that back-to-back packets are counted as one if they are both capped.</spirit:description>
                        <spirit:addressOffset>0x1C</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>wflush_act</spirit:name>
                           <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004FC8</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>drp_pkt_rd</spirit:name>
                        <spirit:description>The count of drop packets flagged to be dropped by the read engine</spirit:description>
                        <spirit:addressOffset>0x20</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>drp_pkt_rd</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004FCC</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>drp_pkt_wr</spirit:name>
                        <spirit:description>The count of drop packets by the write engine</spirit:description>
                        <spirit:addressOffset>0x24</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>drp_pkt_wr</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004FD0</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>flow_ctrl</spirit:name>
                        <spirit:description>The count of the clock cycles the DRDY is asserted low resulting in flow control</spirit:description>
                        <spirit:addressOffset>0x28</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004FD4</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004FAC</address>
                           <context>iso_rex_fifo_write_engine</context>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 
<spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004FA0</address>
                        <context>iso_rex_fifo</context>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : write_engine  --> 

  <!-- reg group
                    :read_engine  --> 
          <spirit:registerFile>
                  <spirit:name>read_engine</spirit:name>
                  <spirit:addressOffset>0x3C</spirit:addressOffset>
                  <spirit:range>0x14</spirit:range>
  <!-- reg group
                    :config0  --> 
          <spirit:registerFile>
                     <spirit:name>config0</spirit:name>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:range>0x4</spirit:range>            
                     <spirit:register>
                        <spirit:name>clear</spirit:name>
                        <spirit:description>Synchronous clear for the read clock domain</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>rclr</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80004FD8</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004FD8</address>
                           <context>iso_rex_fifo_read_engine</context>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : config0  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                     <spirit:name>stats0</spirit:name>
                     <spirit:description>All the Statistic Registers and their configuration for the Read Engine</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:range>0x10</spirit:range>            
                     <spirit:register>
                        <spirit:name>rd2clr_config</spirit:name>
                        <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:bitOffset>2</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>drp_pkt</spirit:name>
                           <spirit:bitOffset>1</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>rflush_act</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004FDC</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>rflush_act</spirit:name>
                        <spirit:description>The counts of number of packets flushed from the PFIFO.</spirit:description>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>rflush_act</spirit:name>
                           <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004FE0</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>drp_pkt</spirit:name>
                        <spirit:description>The counts of drop packet in the PFIFO read engine</spirit:description>
                        <spirit:addressOffset>0x8</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>drp_pkt</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004FE4</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>flow_ctrl</spirit:name>
                        <spirit:description>The count of the clock cycles the DRDY is asserted low resulting in flow control</spirit:description>
                        <spirit:addressOffset>0xC</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004FE8</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004FDC</address>
                           <context>iso_rex_fifo_read_engine</context>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 
<spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004FD8</address>
                        <context>iso_rex_fifo</context>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : read_engine  --> 
<spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004F9C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : iso_rex_fifo  --> 

  <!-- reg group
                    :ctrl_trfr_h2d_fifo  --> 
          <spirit:registerFile>
               <spirit:name>ctrl_trfr_h2d_fifo</spirit:name>
               <spirit:addressOffset>0x1EC</spirit:addressOffset>
               <spirit:range>0x50</spirit:range>            
               <spirit:register>
                  <spirit:name>version</spirit:name>
                  <spirit:description>Version 1.1.0: Added Icron Attributes for stats script generation</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00010100</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>major</spirit:name>
                     <spirit:description>Major version</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000001</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>minor</spirit:name>
                     <spirit:description>Minor version</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000001</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>patch</spirit:name>
                     <spirit:description>Patch version</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004FEC</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
  <!-- reg group
                    :write_engine  --> 
          <spirit:registerFile>
                  <spirit:name>write_engine</spirit:name>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:range>0x38</spirit:range>
  <!-- reg group
                    :config0  --> 
          <spirit:registerFile>
                     <spirit:name>config0</spirit:name>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:range>0xC</spirit:range>            
                     <spirit:register>
                        <spirit:name>clear</spirit:name>
                        <spirit:description>Synchronous clear for the write clock domain</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>wclr</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80004FF0</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>mode</spirit:name>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000005</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>drp_on_sop</spirit:name>
                           <spirit:description>When set, drops the current packet without writing it to the buffer. See Wiki</spirit:description>
                           <spirit:bitOffset>3</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>drp_on_pkt_err</spirit:name>
                           <spirit:description>When set, removes the packet from the buffer without presenting it to the output interface upon the ERR bit being set before the notification point. See Wiki</spirit:description>
                           <spirit:bitOffset>2</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>1</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pkt_strm</spirit:name>
                           <spirit:description>Selects packet based or streaming based behavior. See Wiki</spirit:description>
                           <spirit:bitOffset>1</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>flw_ctrl_en</spirit:name>
                           <spirit:description>Enables the flow control. See Wiki</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>1</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80004FF4</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>notify_limit</spirit:name>
                        <spirit:addressOffset>0x8</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>ntfy_lmt</spirit:name>
                           <spirit:description>Sets the number of words required to be written into the packet FIFO before a notification will be generated. See wiki</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>32</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000000000000000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80004FF8</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004FF0</address>
                           <context>ctrl_trfr_h2d_fifo_write_engine</context>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : config0  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                     <spirit:name>stats0</spirit:name>
                     <spirit:description>All the Statistic Registers and their configuration for the Write Engine</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:range>0x2C</spirit:range>            
                     <spirit:register>
                        <spirit:name>rd2clr_config</spirit:name>
                        <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:bitOffset>9</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>drp_pkt_wr</spirit:name>
                           <spirit:bitOffset>8</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>drp_pkt_rd</spirit:name>
                           <spirit:bitOffset>7</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>wflush_act</spirit:name>
                           <spirit:bitOffset>6</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pkt_sop_err</spirit:name>
                           <spirit:bitOffset>5</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pkt_err</spirit:name>
                           <spirit:bitOffset>4</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>fifo_full_err</spirit:name>
                           <spirit:bitOffset>3</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pkt_max_byte_cnt_err</spirit:name>
                           <spirit:bitOffset>2</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pfifo_dcount</spirit:name>
                           <spirit:bitOffset>1</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>nfifo_dcount</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004FFC</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>nfifo_dcount</spirit:name>
                        <spirit:description>Current level for the notification FIFO in the PFIFO</spirit:description>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>nfifo_dcount</spirit:name>
                           <spirit:description>_icron_water_marker_
_icron_no_counter_</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80005000</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pfifo_dcount</spirit:name>
                        <spirit:description>Current level for the packet FIFO in the PFIFO</spirit:description>
                        <spirit:addressOffset>0x8</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>pfifo_dcount</spirit:name>
                           <spirit:description>_icron_water_marker_
_icron_no_counter_</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80005004</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pkt_max_byte_cnt_err</spirit:name>
                        <spirit:description>The count for capped packets in PFIFO write engine, as the result of reaching maximum size in the PFIFO</spirit:description>
                        <spirit:addressOffset>0xC</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>pkt_max_byte_cnt_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80005008</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>fifo_full_err</spirit:name>
                        <spirit:description>The count for either of PFIFO or NFIFO being full</spirit:description>
                        <spirit:addressOffset>0x10</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>fifo_full_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x8000500C</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pkt_err</spirit:name>
                        <spirit:description>The count of packets tagged to be dropped later in the PFIFO read engine</spirit:description>
                        <spirit:addressOffset>0x14</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>pkt_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80005010</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pkt_sop_err</spirit:name>
                        <spirit:description>The count of packets flushed in the PFIFO during the SOP phase</spirit:description>
                        <spirit:addressOffset>0x18</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>pkt_sop_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80005014</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>wflush_act</spirit:name>
                        <spirit:description>The count of capped packets in the PFIFO. Note that back-to-back packets are counted as one if they are both capped.</spirit:description>
                        <spirit:addressOffset>0x1C</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>wflush_act</spirit:name>
                           <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80005018</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>drp_pkt_rd</spirit:name>
                        <spirit:description>The count of drop packets flagged to be dropped by the read engine</spirit:description>
                        <spirit:addressOffset>0x20</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>drp_pkt_rd</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x8000501C</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>drp_pkt_wr</spirit:name>
                        <spirit:description>The count of drop packets by the write engine</spirit:description>
                        <spirit:addressOffset>0x24</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>drp_pkt_wr</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80005020</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>flow_ctrl</spirit:name>
                        <spirit:description>The count of the clock cycles the DRDY is asserted low resulting in flow control</spirit:description>
                        <spirit:addressOffset>0x28</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80005024</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004FFC</address>
                           <context>ctrl_trfr_h2d_fifo_write_engine</context>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 
<spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004FF0</address>
                        <context>ctrl_trfr_h2d_fifo</context>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : write_engine  --> 

  <!-- reg group
                    :read_engine  --> 
          <spirit:registerFile>
                  <spirit:name>read_engine</spirit:name>
                  <spirit:addressOffset>0x3C</spirit:addressOffset>
                  <spirit:range>0x14</spirit:range>
  <!-- reg group
                    :config0  --> 
          <spirit:registerFile>
                     <spirit:name>config0</spirit:name>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:range>0x4</spirit:range>            
                     <spirit:register>
                        <spirit:name>clear</spirit:name>
                        <spirit:description>Synchronous clear for the read clock domain</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>rclr</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80005028</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80005028</address>
                           <context>ctrl_trfr_h2d_fifo_read_engine</context>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : config0  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                     <spirit:name>stats0</spirit:name>
                     <spirit:description>All the Statistic Registers and their configuration for the Read Engine</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:range>0x10</spirit:range>            
                     <spirit:register>
                        <spirit:name>rd2clr_config</spirit:name>
                        <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:bitOffset>2</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>drp_pkt</spirit:name>
                           <spirit:bitOffset>1</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>rflush_act</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x8000502C</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>rflush_act</spirit:name>
                        <spirit:description>The counts of number of packets flushed from the PFIFO.</spirit:description>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>rflush_act</spirit:name>
                           <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80005030</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>drp_pkt</spirit:name>
                        <spirit:description>The counts of drop packet in the PFIFO read engine</spirit:description>
                        <spirit:addressOffset>0x8</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>drp_pkt</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80005034</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>flow_ctrl</spirit:name>
                        <spirit:description>The count of the clock cycles the DRDY is asserted low resulting in flow control</spirit:description>
                        <spirit:addressOffset>0xC</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80005038</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x8000502C</address>
                           <context>ctrl_trfr_h2d_fifo_read_engine</context>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 
<spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80005028</address>
                        <context>ctrl_trfr_h2d_fifo</context>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : read_engine  --> 
<spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004FEC</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : ctrl_trfr_h2d_fifo  --> 

  <!-- reg group
                    :ctrl_trfr_d2h_fifo  --> 
          <spirit:registerFile>
               <spirit:name>ctrl_trfr_d2h_fifo</spirit:name>
               <spirit:addressOffset>0x23C</spirit:addressOffset>
               <spirit:range>0x50</spirit:range>            
               <spirit:register>
                  <spirit:name>version</spirit:name>
                  <spirit:description>Version 1.1.0: Added Icron Attributes for stats script generation</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00010100</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>major</spirit:name>
                     <spirit:description>Major version</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000001</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>minor</spirit:name>
                     <spirit:description>Minor version</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000001</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>patch</spirit:name>
                     <spirit:description>Patch version</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000503C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
  <!-- reg group
                    :write_engine  --> 
          <spirit:registerFile>
                  <spirit:name>write_engine</spirit:name>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:range>0x38</spirit:range>
  <!-- reg group
                    :config0  --> 
          <spirit:registerFile>
                     <spirit:name>config0</spirit:name>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:range>0xC</spirit:range>            
                     <spirit:register>
                        <spirit:name>clear</spirit:name>
                        <spirit:description>Synchronous clear for the write clock domain</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>wclr</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80005040</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>mode</spirit:name>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000005</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>drp_on_sop</spirit:name>
                           <spirit:description>When set, drops the current packet without writing it to the buffer. See Wiki</spirit:description>
                           <spirit:bitOffset>3</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>drp_on_pkt_err</spirit:name>
                           <spirit:description>When set, removes the packet from the buffer without presenting it to the output interface upon the ERR bit being set before the notification point. See Wiki</spirit:description>
                           <spirit:bitOffset>2</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>1</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pkt_strm</spirit:name>
                           <spirit:description>Selects packet based or streaming based behavior. See Wiki</spirit:description>
                           <spirit:bitOffset>1</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>flw_ctrl_en</spirit:name>
                           <spirit:description>Enables the flow control. See Wiki</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>1</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80005044</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>notify_limit</spirit:name>
                        <spirit:addressOffset>0x8</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>ntfy_lmt</spirit:name>
                           <spirit:description>Sets the number of words required to be written into the packet FIFO before a notification will be generated. See wiki</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>32</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000000000000000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80005048</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80005040</address>
                           <context>ctrl_trfr_d2h_fifo_write_engine</context>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : config0  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                     <spirit:name>stats0</spirit:name>
                     <spirit:description>All the Statistic Registers and their configuration for the Write Engine</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:range>0x2C</spirit:range>            
                     <spirit:register>
                        <spirit:name>rd2clr_config</spirit:name>
                        <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:bitOffset>9</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>drp_pkt_wr</spirit:name>
                           <spirit:bitOffset>8</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>drp_pkt_rd</spirit:name>
                           <spirit:bitOffset>7</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>wflush_act</spirit:name>
                           <spirit:bitOffset>6</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pkt_sop_err</spirit:name>
                           <spirit:bitOffset>5</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pkt_err</spirit:name>
                           <spirit:bitOffset>4</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>fifo_full_err</spirit:name>
                           <spirit:bitOffset>3</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pkt_max_byte_cnt_err</spirit:name>
                           <spirit:bitOffset>2</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pfifo_dcount</spirit:name>
                           <spirit:bitOffset>1</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>nfifo_dcount</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x8000504C</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>nfifo_dcount</spirit:name>
                        <spirit:description>Current level for the notification FIFO in the PFIFO</spirit:description>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>nfifo_dcount</spirit:name>
                           <spirit:description>_icron_water_marker_
_icron_no_counter_</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80005050</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pfifo_dcount</spirit:name>
                        <spirit:description>Current level for the packet FIFO in the PFIFO</spirit:description>
                        <spirit:addressOffset>0x8</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>pfifo_dcount</spirit:name>
                           <spirit:description>_icron_water_marker_
_icron_no_counter_</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80005054</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pkt_max_byte_cnt_err</spirit:name>
                        <spirit:description>The count for capped packets in PFIFO write engine, as the result of reaching maximum size in the PFIFO</spirit:description>
                        <spirit:addressOffset>0xC</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>pkt_max_byte_cnt_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80005058</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>fifo_full_err</spirit:name>
                        <spirit:description>The count for either of PFIFO or NFIFO being full</spirit:description>
                        <spirit:addressOffset>0x10</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>fifo_full_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x8000505C</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pkt_err</spirit:name>
                        <spirit:description>The count of packets tagged to be dropped later in the PFIFO read engine</spirit:description>
                        <spirit:addressOffset>0x14</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>pkt_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80005060</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pkt_sop_err</spirit:name>
                        <spirit:description>The count of packets flushed in the PFIFO during the SOP phase</spirit:description>
                        <spirit:addressOffset>0x18</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>pkt_sop_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80005064</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>wflush_act</spirit:name>
                        <spirit:description>The count of capped packets in the PFIFO. Note that back-to-back packets are counted as one if they are both capped.</spirit:description>
                        <spirit:addressOffset>0x1C</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>wflush_act</spirit:name>
                           <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80005068</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>drp_pkt_rd</spirit:name>
                        <spirit:description>The count of drop packets flagged to be dropped by the read engine</spirit:description>
                        <spirit:addressOffset>0x20</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>drp_pkt_rd</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x8000506C</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>drp_pkt_wr</spirit:name>
                        <spirit:description>The count of drop packets by the write engine</spirit:description>
                        <spirit:addressOffset>0x24</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>drp_pkt_wr</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80005070</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>flow_ctrl</spirit:name>
                        <spirit:description>The count of the clock cycles the DRDY is asserted low resulting in flow control</spirit:description>
                        <spirit:addressOffset>0x28</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80005074</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x8000504C</address>
                           <context>ctrl_trfr_d2h_fifo_write_engine</context>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 
<spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80005040</address>
                        <context>ctrl_trfr_d2h_fifo</context>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : write_engine  --> 

  <!-- reg group
                    :read_engine  --> 
          <spirit:registerFile>
                  <spirit:name>read_engine</spirit:name>
                  <spirit:addressOffset>0x3C</spirit:addressOffset>
                  <spirit:range>0x14</spirit:range>
  <!-- reg group
                    :config0  --> 
          <spirit:registerFile>
                     <spirit:name>config0</spirit:name>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:range>0x4</spirit:range>            
                     <spirit:register>
                        <spirit:name>clear</spirit:name>
                        <spirit:description>Synchronous clear for the read clock domain</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>rclr</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80005078</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80005078</address>
                           <context>ctrl_trfr_d2h_fifo_read_engine</context>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : config0  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                     <spirit:name>stats0</spirit:name>
                     <spirit:description>All the Statistic Registers and their configuration for the Read Engine</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:range>0x10</spirit:range>            
                     <spirit:register>
                        <spirit:name>rd2clr_config</spirit:name>
                        <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:bitOffset>2</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>drp_pkt</spirit:name>
                           <spirit:bitOffset>1</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>rflush_act</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x8000507C</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>rflush_act</spirit:name>
                        <spirit:description>The counts of number of packets flushed from the PFIFO.</spirit:description>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>rflush_act</spirit:name>
                           <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80005080</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>drp_pkt</spirit:name>
                        <spirit:description>The counts of drop packet in the PFIFO read engine</spirit:description>
                        <spirit:addressOffset>0x8</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>drp_pkt</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80005084</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>flow_ctrl</spirit:name>
                        <spirit:description>The count of the clock cycles the DRDY is asserted low resulting in flow control</spirit:description>
                        <spirit:addressOffset>0xC</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80005088</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x8000507C</address>
                           <context>ctrl_trfr_d2h_fifo_read_engine</context>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 
<spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80005078</address>
                        <context>ctrl_trfr_d2h_fifo</context>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : read_engine  --> 
<spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x8000503C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : ctrl_trfr_d2h_fifo  --> 

  <!-- reg group
                    :ctrl_trfr  --> 
          <spirit:registerFile>
               <spirit:name>ctrl_trfr</spirit:name>
               <spirit:description>All the Statistic Registers and their configuration</spirit:description>
               <spirit:addressOffset>0x28C</spirit:addressOffset>
               <spirit:range>0x24</spirit:range>            
               <spirit:register>
                  <spirit:name>h2d_data</spirit:name>
                  <spirit:description>Control Transfer packet Data portion for the Host to Device</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>h2d_data</spirit:name>
                     <spirit:description>Data of the packet for Host to Device. Data is filled from the most significant (31:24) byte</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>32</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000000000000000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x8000508C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>h2d_ctrl</spirit:name>
                  <spirit:description>Control Transfer packet sideband signals for Host to Device</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>srdy</spirit:name>
                     <spirit:description>Validity of h2d</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>time_tag</spirit:name>
                     <spirit:description>Event time tag recorded in each cycle.</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>12</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>vlane</spirit:name>
                     <spirit:description>Valid number of "lanes" where each lane is one bye</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>2</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>eop</spirit:name>
                     <spirit:description>End of Packet</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sop</spirit:name>
                     <spirit:description>Start of Packet</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80005090</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>h2d_skip</spirit:name>
                  <spirit:description>This register allows the software to skip certain number of cycles in the h2d data and control registers.</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>cycles</spirit:name>
                     <spirit:description>Write once into this register with the number of cycles that the h2d_data and h2d_ctrl need to be skipped. A zero value will skip to the eop of the packet.
</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                        <ids_properties>
                           <rtl.hw_wp>1</rtl.hw_wp>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80005094</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>h2d_dbg</spirit:name>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000802</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>squelch_en</spirit:name>
                     <spirit:description>Set to 1 to zero out the data sent to the SW when injecting CRC32 error in the Control Transfer. Note that the data is squelched from the third cycle (from bytes 9) onwards, including the CRC32. Also note that the data is NOT squelched to the Device and only CRC32 is errored.</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>crc32_term_value</spirit:name>
                     <spirit:description>Every time a Control data packet is seen, a counter is incremented. When this terminus value is reached, the counter resets back to 0.

Note value of 0 is NOT valid.</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>10</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000001</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>crc32_err_inj_en</spirit:name>
                     <spirit:description>Set to 1 to enable the CRC32 error injection logic and counter in the Control Transfers.
When enabled, the counter is enabled and the logic will inject CRC32 errors when the crc32_term_value is reached in the counter.</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80005098</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>d2h_data</spirit:name>
                  <spirit:description>Control Transfer packet Data portion for the Device to Host</spirit:description>
                  <spirit:addressOffset>0x10</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>d2h_data</spirit:name>
                     <spirit:description>Data of the packet for Device to Host. Data is filled from the most significant (31:24) byte</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>32</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000000000000000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x8000509C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>d2h_ctrl</spirit:name>
                  <spirit:description>Control Transfer packet sideband signals for Device to Host</spirit:description>
                  <spirit:addressOffset>0x14</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>srdy</spirit:name>
                     <spirit:description>Validity of d2h</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>time_tag</spirit:name>
                     <spirit:description>Event time tag recorded in each cycle.</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>12</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>vlane</spirit:name>
                     <spirit:description>Valid number of "lanes" where each lane is one bye</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>2</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>eop</spirit:name>
                     <spirit:description>End of Packet</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sop</spirit:name>
                     <spirit:description>Start of Packet</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x800050A0</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>d2h_skip</spirit:name>
                  <spirit:description>This register allows the software to skip certain number of cycles in the d2h data and control registers.</spirit:description>
                  <spirit:addressOffset>0x18</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>cycles</spirit:name>
                     <spirit:description>Write once into this register with the number of cycles that the d2h_data and d2h_ctrl need to be skipped. A zero value will skip to the eop of the packet.
</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                        <ids_properties>
                           <rtl.hw_wp>1</rtl.hw_wp>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800050A4</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>d2h_dbg</spirit:name>
                  <spirit:addressOffset>0x1C</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000802</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>squelch_en</spirit:name>
                     <spirit:description>Set to 1 to zero out the data sent to the SW when injecting CRC32 error in the Control Transfer. Note that the data is squelched from the third cycle (from bytes 9) onwards, including the CRC32. Also note that the data is NOT squelched to the Host and only CRC32 is errored.</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>crc32_term_value</spirit:name>
                     <spirit:description>Every time a Control data packet is seen, a counter is incremented. When this terminus value is reached, the counter resets back to 0.

Note value of 0 is NOT valid.</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>10</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000001</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>crc32_err_inj_en</spirit:name>
                     <spirit:description>Set to 1 to enable the CRC32 error injection logic and counter in the Control Transfers.
When enabled, the counter is enabled and the logic will inject CRC32 errors when the crc32_term_value is reached in the counter.</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800050A8</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>cmpltd</spirit:name>
                  <spirit:description>When Software completes processing a Control Transfer, it writes into this register to signal the completion of the processing for the Transfer</spirit:description>
                  <spirit:addressOffset>0x20</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>device_addr</spirit:name>
                     <spirit:description>Device Address that the Software completed processing its Control Transfer
</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>7</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000</ids:default_value>
                        <ids_properties>
                           <rtl.hw_wp>1</rtl.hw_wp>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800050AC</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x8000508C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : ctrl_trfr  --> 

  <!-- reg group
                    :endpoint_tbl  --> 
          <spirit:registerFile>
               <spirit:name>endpoint_tbl</spirit:name>
               <spirit:addressOffset>0x2B0</spirit:addressOffset>
               <spirit:range>0x10</spirit:range>            
               <spirit:register>
                  <spirit:name>config0</spirit:name>
                  <spirit:description>This register is used to configure the EndPoint Table (EPT) in the logic for IN Endpoints. It is the lowest 32 bit word. See config1 for the upper 32 bit word.

Software shall write into this register to initiate and configure the EPT, when it has already written into the upper "word" (config1)

NOTE**: A write into any field shall result in an update of the EPT. Therefore, the register should be updated once for a set of data and individual fields should not be written into unless other fields are kept as before.

NOTE**: When writing into this "word", the data in the second "word" (config1) MUST be valid.
</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>null_en</spirit:name>
                     <spirit:description>Set to 1 to null out the EndPoint. 

Currently, this only applies to the ISO EndPoints (bm_attributes_tt=1). 

When this bit is set, it blocks the ACK to reach the Device and terminates the ACK on the LEX by sending Null Data Packets to the Host.

When this bit is set, the qid MUST be 0.
</spirit:description>
                     <spirit:bitOffset>21</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>bm_attributes_tt</spirit:name>
                     <spirit:description>This field is configured based on the Transfer Type bits of bmAttritues of Table 9-24 in Section 9.6.6.

Set to 0 to remove the EndPoint
Set to 1 for ISO IN endpoints
Set to 2 for Bulk IN endpoints
set to 3 for Interrupts IN endpoints
</spirit:description>
                     <spirit:bitOffset>19</spirit:bitOffset>
                     <spirit:bitWidth>2</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>qid</spirit:name>
                     <spirit:description>The Queue ID (QID) is the buffer number that the duality of is assigned to. 

The total number of QIDs available is reported in qid_total_num. Also, the up to date assignment of QIDs are reported in qid_assigned. 

Note that QID=0 is always assigned to "non-ISO" traffic needed in the logic and cannot be assigned by the software for any ISO traffic. However, when null_en is set, the qid MUST be 0 for the ISO EndPoints.</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>device_addr</spirit:name>
                     <spirit:description>This is the USB Device Address in the EPT</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>7</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ept_num</spirit:name>
                     <spirit:description>This is the USB Endpoint Number in the EPT

</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000</ids:default_value>
                        <ids_properties>
                           <rtl.hw_wp>1</rtl.hw_wp>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800050B0</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>config1</spirit:name>
                  <spirit:description>This register is used to configure the EndPoint Table (EPT) in the logic for IN Endpoints. It is the highest 32 bit word. See config0 for the lower 32 bit word.

NOTE**: The data in this "word" MUST be written before attempting to write into the lower "word" (config0). 
</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000001</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>crdt_chk_value</spirit:name>
                     <spirit:description>An indication of a "guard" before ITP boundary. It is a value of Total "Credit" (each one being a full DP) left before end of ITP. Typically, this should be zero. Any larger value could limit the bandwidth used.</spirit:description>
                     <spirit:bitOffset>20</spirit:bitOffset>
                     <spirit:bitWidth>2</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>max_burst</spirit:name>
                     <spirit:description>This field should be set such that it is not more than the Value of bMaxBurst of Section 9.6.7 and at the same time it does not impact the system performance with a large value. Typical values of 2 or 3 (if the device bMaxBurst is more than these values) could be a god compromise in most setups. If bMaxBurst is smaller than typical values above, this field should be the exact number equal to bMaxBurst.</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>coded_binterval</spirit:name>
                     <spirit:description>Hot coding to show the number of BInterval of Section 9.6.6. As example, BInterval=1 ---&gt;coded_binterval=2^0; BInterval=7 ---&gt; coded_binterval=2^6; BInterval=16 ---&gt; coded_binterval=2^15</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000001</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800050B4</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>total_qid</spirit:name>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000001</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>total_qid</spirit:name>
                     <spirit:description>Total number of QID that has been implemented in the logic.</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000001</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800050B8</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>qid_assigned0</spirit:name>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000001</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>qid_assigned0</spirit:name>
                     <spirit:description>One-hot encoded register that shows which QID is currently assigned. A one (1) in each bit position indicates that QID is already assigned.</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>32</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000000000000000000000000001</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800050BC</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x800050B0</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : endpoint_tbl  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
               <spirit:name>stats0</spirit:name>
               <spirit:description>All the Statistic Registers and their configuration</spirit:description>
               <spirit:addressOffset>0x2C0</spirit:addressOffset>
               <spirit:range>0x8</spirit:range>            
               <spirit:register>
                  <spirit:name>rd2clr_config</spirit:name>
                  <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>missing_itp</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x800050C0</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>missing_itp</spirit:name>
                  <spirit:description>Count the number ITP packets that did not receive at the REX</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>missing_itp</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x800050C4</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x800050C0</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 

  <!-- reg group
                    :irq0  --> 
          <spirit:registerFile>
               <spirit:name>irq0</spirit:name>
               <spirit:description>Define the IRQ group</spirit:description>
               <spirit:addressOffset>0x2C8</spirit:addressOffset>
               <spirit:range>0x10</spirit:range>            
               <spirit:register>
                  <spirit:name>enable</spirit:name>
                  <spirit:description>The enable for the actual interrupt signals. Writing a 1 enables the interrupt.
</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>d2h_pkt</spirit:name>
                     <spirit:description>Fires on availability of a packet in the Data to Host path in Control Transfer</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>h2d_pkt</spirit:name>
                     <spirit:description>Fires on availability of a packet in the Host to Data path in Control Transfer</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800050C8</address>
                        <intr.enable>irq0_upp</intr.enable>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending</spirit:name>
                  <spirit:description>The actual interrupt(s) that has triggered. Write a 1 to clear.
</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>d2h_pkt</spirit:name>
                     <spirit:description>Fires on availability of a packet in the Data to Host path in Control Transfer</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>h2d_pkt</spirit:name>
                     <spirit:description>Fires on availability of a packet in the Host to Data path in Control Transfer</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800050CC</address>
                        <intr.status>irq0_upp</intr.status>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending_irq</spirit:name>
                  <spirit:description>Registered version of pending &amp; enable
</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>d2h_pkt</spirit:name>
                     <spirit:description>Fires on availability of a packet in the Data to Host path in Control Transfer</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>h2d_pkt</spirit:name>
                     <spirit:description>Fires on availability of a packet in the Host to Data path in Control Transfer</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800050D0</address>
                        <intr.pending>irq0_upp</intr.pending>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>raw</spirit:name>
                  <spirit:description>The status registered values for the interrupt signals, if applicable.</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>d2h_pkt</spirit:name>
                     <spirit:description>Not used</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>h2d_pkt</spirit:name>
                     <spirit:description>Not used</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800050D4</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x800050C8</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : irq0  --> 

  <!-- reg group
                    :irq1  --> 
          <spirit:registerFile>
               <spirit:name>irq1</spirit:name>
               <spirit:description>Define the IRQ group</spirit:description>
               <spirit:addressOffset>0x2D8</spirit:addressOffset>
               <spirit:range>0x10</spirit:range>            
               <spirit:register>
                  <spirit:name>enable</spirit:name>
                  <spirit:description>The enable for the actual interrupt signals. Writing a 1 enables the interrupt.
</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>ping_not_respond</spirit:name>
                     <spirit:description>Each bit fires on an ISO device not responding to PING REQUESTs for a defined number of times. The bit position refers to the EndPoint Queue.</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>iso_not_respond</spirit:name>
                     <spirit:description>Each bit fires on an ISO device not responding for a defined number of times. The bit position refers to the EndPoint Queue.</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800050D8</address>
                        <intr.enable>irq1_upp</intr.enable>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending</spirit:name>
                  <spirit:description>The actual interrupt(s) that has triggered. Write a 1 to clear.
</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>ping_not_respond</spirit:name>
                     <spirit:description>Each bit fires on an ISO device not responding to PING REQUESTs for a defined number of times. The bit position refers to the EndPoint Queue.</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>iso_not_respond</spirit:name>
                     <spirit:description>Each bit fires on an ISO device not responding for a defined number of times. The bit position refers to the EndPoint Queue.</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800050DC</address>
                        <intr.status>irq1_upp</intr.status>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending_irq</spirit:name>
                  <spirit:description>Registered version of pending &amp; enable
</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>ping_not_respond</spirit:name>
                     <spirit:description>Each bit fires on an ISO device not responding to PING REQUESTs for a defined number of times. The bit position refers to the EndPoint Queue.</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>iso_not_respond</spirit:name>
                     <spirit:description>Each bit fires on an ISO device not responding for a defined number of times. The bit position refers to the EndPoint Queue.</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800050E0</address>
                        <intr.pending>irq1_upp</intr.pending>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>raw</spirit:name>
                  <spirit:description>The status registered values for the interrupt signals, if applicable.</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>ping_not_respond</spirit:name>
                     <spirit:description>Not used</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>iso_not_respond</spirit:name>
                     <spirit:description>Not used</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800050E4</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x800050D8</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : irq1  --> 
         <spirit:vendorExtensions>
               <ids_properties>
                  <module_name>upp_regs</module_name>
                  <uvm.package>upp_regs_pkg</uvm.package>
                  <reset_type>async</reset_type>
                  <cheader.mask_endianess>little</cheader.mask_endianess>
                  <header.struct_guard>__ASSEMBLER__</header.struct_guard>
                  <explicit_name>true</explicit_name>
                  <vertical_reuse>true</vertical_reuse>
                  <address>0x80004E00</address>
               </ids_properties>
            </spirit:vendorExtensions>
         </spirit:addressBlock>     
         <spirit:addressBlock>     
            <spirit:name>ulp_core</spirit:name>
            <spirit:description>ULP Registers
</spirit:description>  <!-- //
                        block : ulp_core  --> 
            <spirit:baseAddress>0x80005100</spirit:baseAddress>               
            <spirit:range>0x200</spirit:range>               
            <spirit:width>32</spirit:width>            
            <spirit:register>
               <spirit:name>version</spirit:name>
               <spirit:description>8.0.1: Cleanup and add synchronizer to phy_reset_n to avoid direct path to the output pad
8.1.0: Changed the Interrupt Pending to avoid blocking the register update when enable is 0
8.2.0: Added pending_irq register
8.3.0: Fixed Hot Reset bug; Added in_u0 to the 'rdy' to the top level; Bring in_hot_reset and in_warm_reset to upper layer
8.3.1: Cap Remote RX Credit Count to 4
8.4.0: Changed from Logic to Wire for ift_ulp_pipe
8.5.0: Add Timer Corrections
8.5.1: Bug fixes
8.5.2: Bug fixes (5466, 4724, 4808)
8.5.3: Address timing issues for previous fix
8.5.4: Infinite Loop and signal reset assignment missing fixed
9.0.0: Many Enhancement and bug fixes for LFPS, Polarity Detection, RX Detect, data exception handing, U3 wakeup, register operations, etc</spirit:description>
               <spirit:addressOffset>0x0</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00090000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>major</spirit:name>
                  <spirit:description>Major version</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00001001</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>minor</spirit:name>
                  <spirit:description>Minor version</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>patch</spirit:name>
                  <spirit:description>Patch version</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80005100</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>configuration</spirit:name>
               <spirit:addressOffset>0x4</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000180</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>credit_hp_timer_en</spirit:name>
                  <spirit:description>When 1, it enables the Credit_HP_Timer</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>1</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>pending_hp_timer_en</spirit:name>
                  <spirit:description>When 1, it enables the Pending_HP_Timer</spirit:description>
                  <spirit:bitOffset>7</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>1</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>internal_loopback_en</spirit:name>
                  <spirit:description>When 1 it enables an RX Loopback (Section 6.8.4) implementation in the USB Link Layer rather than the PHY</spirit:description>
                  <spirit:bitOffset>6</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>quasi_ss_disabled_mode</spirit:name>
                  <spirit:description>When 1, it puts the USB PHY into P2 power mode rather than the normal P3 as required by the Standard</spirit:description>
                  <spirit:bitOffset>5</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>quasi_u3_mode</spirit:name>
                  <spirit:description>When 1, it handshakes U3 protocol with the USB partner but puts the USB PHY into P2 low power mode.

This mode could be used for debugging, or in case of any bug in normal U3 mode as USB PHY PCLK is removed in U3</spirit:description>
                  <spirit:bitOffset>4</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>allow_u2</spirit:name>
                  <spirit:description>Assert high to allow U2 Low Power request to be processed. When low, it will always issue LXU. Section 7.2.4.2.3 Item 3</spirit:description>
                  <spirit:bitOffset>3</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>allow_u1</spirit:name>
                  <spirit:description>Assert high to allow U1 Low Power request to be processed. When low, it will always issue LXU. Section 7.2.4.2.3 Item 3</spirit:description>
                  <spirit:bitOffset>2</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>dfp_compliance_mode_en</spirit:name>
                  <spirit:description>Section 7.5.4.3.1 Item 4: 
A downstream port shall enable its transition path to Compliance Mode, if directed</spirit:description>
                  <spirit:bitOffset>1</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>use_trx_detect_quiet_dfp_max</spirit:name>
                  <spirit:description>Section 7.5.3.7.1 and Table 7-12 (Note 1): 
Implementations are recommended to consider system states when choosing when to use a larger value of the
tRxDetectQuietTimeoutDFP timer. Using a smaller value when the system is active and a larger value when the system is in
a standby/sleep or other idle state allows for higher responsiveness to connect events during active states while enabling
power savings in an idle system state.</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80005104</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>control</spirit:name>
               <spirit:addressOffset>0x8</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000800</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>wait_in_polling_lfps</spirit:name>
                  <spirit:description>When 1, it instructs the port to wait in Polling.LFPS. Note this wait is NOT based on standard but only for LEX/REX extension benefit. Also note the 360 ms timer of this state
  </spirit:description>
                  <spirit:bitOffset>21</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>exit_low_power</spirit:name>
                  <spirit:description>Assert high to initiate exit from U1, U2, or U3 Low Power. Section 7.2.4.2.7 and Sections 7.5.8.2 Item 7, 7.5.8.2 Item 6, and 7.5.9.2 Item 5

Write a 1 and HW clears
</spirit:description>
                  <spirit:bitOffset>20</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                     <ids_properties>
                        <rtl.hw_clear>true</rtl.hw_clear>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>wait_in_u3</spirit:name>
                  <spirit:description>When set, allows the software to hold the port in its exit handshaking (either initiated by link partner or self initiated) to come out U3 following Section 7.2.4.2.7.

Note the limit time based on Table 6-30 in Section 6.9.2. A 20ms for U3 (t13-t10)</spirit:description>
                  <spirit:bitOffset>19</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>wait_in_u1_u2</spirit:name>
                  <spirit:description>When set, allow the software to hold the port in its exit handshaking (either initiated by link partner or self initiated) to come out U1, U2 following Section 7.2.4.2.7.

Note the limit time based on Table 6-30 in Section 6.9.2. A 2ms for U1/U2 (t13-t10)</spirit:description>
                  <spirit:bitOffset>18</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>delay_u3_wakeup</spirit:name>
                  <spirit:description>Assert high to delay the start of the wakeup. This applies to both when the port is Master (initiating) of U3 wakeup or Slave (responding) to U3 wakeup. 

In effect, it will delay t10 of Figure 6-30 when it is Master or t11 when it is Slave.

NOTE: 

If this bit is set when the port is a master of wakeup and remains asserted, it will result in squelching the wakeup LFPS. If it remains asserted for over 10ms, an interrupt is issued informing software of a wakeup failure, as the Slave will never see wakeup to be able to respond. Both ports will remain in U3. In this configuration, this bit can be used as a test bit as well.

If this bit is et when the port is a slave of wakeup and remains asserted, the master port will see a tNOLFPSReponseTimeout and both ports remain in U3. In this configuration, this bit can be used as a test bit.</spirit:description>
                  <spirit:bitOffset>17</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>go_u3</spirit:name>
                  <spirit:description>Assert high to initiate a U3 Low Power when in U0. Section 7.2.4.2.3 and Section 7.5.6.2 Item 3
NOTE: This can only be done when it is a downstream port. Otherwise, no action is taken

Write a 1 and HW clears it
</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                     <ids_properties>
                        <rtl.hw_clear>true</rtl.hw_clear>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>go_u2</spirit:name>
                  <spirit:description>Assert high to initiate a U2 Low Power when in U0. Section 7.2.4.2.3 and Section 7.5.6.2 Item 2

Write a 1 and HW clears it
</spirit:description>
                  <spirit:bitOffset>15</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                     <ids_properties>
                        <rtl.hw_clear>true</rtl.hw_clear>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>go_u1</spirit:name>
                  <spirit:description>Assert high to initiate a U1 Low Power when in U0. Section 7.2.4.2.3 and Section 7.5.6.2 Item 1

Write a 1 and HW clears it
</spirit:description>
                  <spirit:bitOffset>14</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                     <ids_properties>
                        <rtl.hw_clear>true</rtl.hw_clear>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>wait_in_hot_reset</spirit:name>
                  <spirit:description>When set, allows the software to kepp the port in hot reset whenever it enters and, thus, prevents the handshake of HotReset.Active in Section 7.5.12.3.2 to complete. 

Note the 12 ms timer for tHotResetActiveTimeout as the LTSSM will slip into eSS.Inactive from the Hot Reset state on expiry of this timer
 </spirit:description>
                  <spirit:bitOffset>13</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>gen_warm_reset</spirit:name>
                  <spirit:description>Section 6.9.3: A downstream port may issue a Warm Reset at any Link states except SS.Disabled. 
 See also 10.3.1.6, the Resetting State of a Downstream Port

Write a 1 and HW clears it
</spirit:description>
                  <spirit:bitOffset>12</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                     <ids_properties>
                        <rtl.hw_clear>true</rtl.hw_clear>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>allow_rx_term_en_hw_clr</spirit:name>
                  <spirit:description>When set to 1, it allows the Hardware to self clear rx_termination_en when entering back into rx_termination reset. When set to 0, the hardware does not clear rx_termination_en bit at any time.
</spirit:description>
                  <spirit:bitOffset>11</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>1</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>rx_termination_en</spirit:name>
                  <spirit:description>Enable presenting ULP RX termination. Set to 1 when the port is to present its RX Termination to the USB partner. Writing a 0, will remove the termination to the USB partner and enables a "stealth mode".

HW clears this bit (when allow_rx_term_en_hw_clr is asserted) when the LTSSM goes into the RX.Detect.Reset
</spirit:description>
                  <spirit:bitOffset>10</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                     <ids_properties>
                        <rtl.hw_clear>true</rtl.hw_clear>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>go2_ss_inactive</spirit:name>
                  <spirit:description>Section 7.5.6.2 Item 10, A downstream port shall transition to eSS.Inactive when directed

Write a 1 and HW clears it
</spirit:description>
                  <spirit:bitOffset>9</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                     <ids_properties>
                        <rtl.hw_clear>true</rtl.hw_clear>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>go2_recovery</spirit:name>
                  <spirit:description>Section 7.5.6.2 Item 7: The port shall transition to Recovery when directed

Write a 1 and HW clears it
</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                     <ids_properties>
                        <rtl.hw_clear>true</rtl.hw_clear>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>go2_hot_reset</spirit:name>
                  <spirit:description>Section 7.5.10.5.2 Item 5: A downstream port shall transition to Hot Reset when directed

Write a 1 and HW clears it when completed the action
</spirit:description>
                  <spirit:bitOffset>7</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                     <ids_properties>
                        <rtl.hw_clear>true</rtl.hw_clear>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>go2_loopback</spirit:name>
                  <spirit:description>Section 7.5.4.10.2 Item 1, 7.5.10.5.2 Item 1: The port shall transition to Loopback when directed as a loopback master and the port is capable of being a loopback master

Write a 1 and HW clears it when completed the action


NOTE: Not Implemented, as we are always a loopback slave</spirit:description>
                  <spirit:bitOffset>6</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                     <ids_properties>
                        <rtl.hw_clear>true</rtl.hw_clear>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>go2_ss_disabled</spirit:name>
                  <spirit:description>Sections 7.5.6.2 Item 11 , 7.5.2.3.2 , 7.5.3.3.2, 7.5.3.6, 7.5.3.7.2, 7.5.4.3.2, 7.5.4.7.2, 7.5.4.8.2 Item 10, 7.5.4.9.2 Item 10, 7.5.4.10.2 Item 6, 7.5.6.2 Item 9, 7.5.6.2 Item 11, 7.5.10.3.2 Item 5, 7.5.10.4.2 Item 5, 7.5.10.5.2 Item 6

Write a 1 and HW clears it.
</spirit:description>
                  <spirit:bitOffset>5</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                     <ids_properties>
                        <rtl.hw_clear>true</rtl.hw_clear>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>disable_scrambling</spirit:name>
                  <spirit:description>Section 7.5.4.10.1 Item 5: ( This is for the TX Scrambler) The port in SuperSpeed operation shall disable the scrambling if directed</spirit:description>
                  <spirit:bitOffset>4</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>set_ts2_disable_scramble_bit</spirit:name>
                  <spirit:description>Section 7.5.4.9.1 Item 1.3: When directed, the port shall set the Disabling Scrambling bit in the TS2 ordered set. This shall eventually be used in the RX De-Scrambler</spirit:description>
                  <spirit:bitOffset>3</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>set_ts2_loopbk_bit</spirit:name>
                  <spirit:description>Not Used -Will be Removed</spirit:description>
                  <spirit:bitOffset>2</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>set_ts2_link_config_field</spirit:name>
                  <spirit:description>Not Used -Will be Removed</spirit:description>
                  <spirit:bitOffset>1</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>go2_rx_detect</spirit:name>
                  <spirit:description>Section 7.5.1.1.2 Item 1: A downstream port shall transition to Rx.Detect when directed

Write a 1 and HW clears it.
</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                     <ids_properties>
                        <rtl.hw_clear>true</rtl.hw_clear>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80005108</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>timer_correction</spirit:name>
               <spirit:addressOffset>0xC</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000042</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>add_2_cht</spirit:name>
                  <spirit:description>Each value adds (2^13)*8 ns (8 is the result of the block running at 125MHz) to the CREDIT_HP_TIMER of Table 7-7. Hence, value of 2 adds 2*8192*8=131.072us</spirit:description>
                  <spirit:bitOffset>5</spirit:bitOffset>
                  <spirit:bitWidth>5</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00010</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>add_2_pht</spirit:name>
                  <spirit:description>Each value adds (2^5)*8 ns (8 is the result of the block running at 125MHz) to the PENDING_HP_TIMER of Table 7-7. Hence, value of 2 adds 2*32*8=512ns</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>5</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00010</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x8000510C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>ltssm_state</spirit:name>
               <spirit:description>Shows the LTSSM State at the time</spirit:description>
               <spirit:addressOffset>0x10</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>main_state</spirit:name>
                  <spirit:description>This is the main state of the LTSSM as listed in the Standard Section 7.5</spirit:description>
                  <spirit:bitOffset>4</spirit:bitOffset>
                  <spirit:bitWidth>4</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>sub_state</spirit:name>
                  <spirit:description>This is the sub state of the LTSSM as listed in the Standard Section 7.5</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>4</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80005110</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>
  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
               <spirit:name>stats0</spirit:name>
               <spirit:description>All the Statistic Registers and their configuration for the ULP Core Clock</spirit:description>
               <spirit:addressOffset>0x14</spirit:addressOffset>
               <spirit:range>0x50</spirit:range>            
               <spirit:register>
                  <spirit:name>rd2clr_config</spirit:name>
                  <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>rcvd_lbad</spirit:name>
                     <spirit:bitOffset>18</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rcvd_lrty</spirit:name>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>snt_lbad</spirit:name>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>snt_lrty</spirit:name>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_go_recovery</spirit:name>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>go2_u0_from_recovery</spirit:name>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>to_phy_out_eop</spirit:name>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>to_phy_out_sop</spirit:name>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>remote_rx_hdr_buff_crdt_cnt_in_err</spirit:name>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lmp_rx_event_fifo_underflow</spirit:name>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lmp_rx_event_fifo_overflow</spirit:name>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>link_command_rx_event_fifo_underflow</spirit:name>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>link_command_rx_event_fifo_overflow</spirit:name>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lmp_ptp_violated</spirit:name>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>link_command_ptp_violated</spirit:name>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>link_training_ptp_violated</spirit:name>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_framer_ptp_violated</spirit:name>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_lfps_cnt_in_err</spirit:name>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_lfps_cnt_in_err</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80005114</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>tx_lfps_cnt_in_err</spirit:name>
                  <spirit:description>Count of the number of TX LFPS counter going beyond the largest value possible</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>tx_lfps_cnt_in_err</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80005118</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>rx_lfps_cnt_in_err</spirit:name>
                  <spirit:description>Count of the number of RX LFPS counter going beyond the largest value possible</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>rx_lfps_cnt_in_err</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x8000511C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>tx_framer_ptp_violated</spirit:name>
                  <spirit:description>Count the number of PTP Protocol Violation in the TX Frame Manager</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>tx_framer_ptp_violated</spirit:name>
                     <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80005120</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>link_training_ptp_violated</spirit:name>
                  <spirit:description>Count the number of PTP Protocol Violation in the Link Training Manager</spirit:description>
                  <spirit:addressOffset>0x10</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>link_training_ptp_violated</spirit:name>
                     <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80005124</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>link_command_ptp_violated</spirit:name>
                  <spirit:description>Count the number of PTP Protocol Violation in the Link Command Manager</spirit:description>
                  <spirit:addressOffset>0x14</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>link_command_ptp_violated</spirit:name>
                     <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80005128</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>lmp_ptp_violated</spirit:name>
                  <spirit:description>Count the number of PTP Protocol Violation in the LMP Manager</spirit:description>
                  <spirit:addressOffset>0x18</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>lmp_ptp_violated</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x8000512C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>link_command_rx_event_fifo_overflow</spirit:name>
                  <spirit:description>Count the number of Link Command RX Event FIFO Overflow</spirit:description>
                  <spirit:addressOffset>0x1C</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>link_command_rx_event_fifo_overflow</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80005130</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>link_command_rx_event_fifo_underflow</spirit:name>
                  <spirit:description>Count the number of Link Command RX Event FIFO Underflow</spirit:description>
                  <spirit:addressOffset>0x20</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>link_command_rx_event_fifo_underflow</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80005134</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>lmp_rx_event_fifo_overflow</spirit:name>
                  <spirit:description>Count the number of LMP Manager RX Event FIFO Overflow</spirit:description>
                  <spirit:addressOffset>0x24</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>lmp_rx_event_fifo_overflow</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80005138</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>lmp_rx_event_fifo_underflow</spirit:name>
                  <spirit:description>Count the number of LMP Manager RX Event FIFO Underflow</spirit:description>
                  <spirit:addressOffset>0x28</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>lmp_rx_event_fifo_underflow</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x8000513C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>remote_rx_hdr_buff_crdt_cnt_in_err</spirit:name>
                  <spirit:description>Count the number of Remote RX Header Buffer Credit Count erroneous increment or decrement</spirit:description>
                  <spirit:addressOffset>0x2C</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>remote_rx_hdr_buff_crdt_cnt_in_err</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80005140</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>to_phy_out_sop</spirit:name>
                  <spirit:description>Count the number of PTP sop to the PHY path</spirit:description>
                  <spirit:addressOffset>0x30</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>to_phy_out_sop</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>32</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000000000000000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80005144</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>to_phy_out_eop</spirit:name>
                  <spirit:description>Count the number of PTP eop to the PHY path</spirit:description>
                  <spirit:addressOffset>0x34</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>to_phy_out_eop</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>32</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000000000000000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80005148</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>go2_u0_from_recovery</spirit:name>
                  <spirit:description>Count of the number of times LTSSM move from Recovery to U0</spirit:description>
                  <spirit:addressOffset>0x38</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>go2_u0_from_recovery</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x8000514C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>rx_go_recovery</spirit:name>
                  <spirit:description>Count of the number of recovery initiated due to received data from PHY (Section 7.6.6.2 Item 5)</spirit:description>
                  <spirit:addressOffset>0x3C</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>rx_go_recovery</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80005150</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>snt_lrty</spirit:name>
                  <spirit:description>Count of the number of times the ULP has sent LRTY to its partner in response to receiving LBAD from its partner</spirit:description>
                  <spirit:addressOffset>0x40</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>snt_lrty</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80005154</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>snt_lbad</spirit:name>
                  <spirit:description>Count of the number of times the ULP has sent LBAD to its partner</spirit:description>
                  <spirit:addressOffset>0x44</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>snt_lbad</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80005158</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>rcvd_lrty</spirit:name>
                  <spirit:description>Count of the number of times the ULP has received LRTY from its partner in response to an earlier ULP sending LBAD</spirit:description>
                  <spirit:addressOffset>0x48</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>rcvd_lrty</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x8000515C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>rcvd_lbad</spirit:name>
                  <spirit:description>Count of the number of times the ULP has received LBAD from its partner</spirit:description>
                  <spirit:addressOffset>0x4C</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>rcvd_lbad</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80005160</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80005114</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 

  <!-- reg group
                    :ptp_guard_2core  --> 
          <spirit:registerFile>
               <spirit:name>ptp_guard_2core</spirit:name>
               <spirit:addressOffset>0x64</spirit:addressOffset>
               <spirit:range>0x2C</spirit:range>            
               <spirit:register>
                  <spirit:name>version</spirit:name>
                  <spirit:description>3.1.0: Fixed bug in Max Cycle Error where in certain mode the cycles were included in the count
3.2.0: Changed the Interrupt Pending to avoid blocking the register update when enable is 0
3.3.0: Added pending_irq register</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00030300</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>major</spirit:name>
                     <spirit:description>Major version</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000011</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>minor</spirit:name>
                     <spirit:description>Minor version</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000011</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>patch</spirit:name>
                     <spirit:description>Patch version</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80005164</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
  <!-- reg group
                    :config0  --> 
          <spirit:registerFile>
                  <spirit:name>config0</spirit:name>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:range>0x8</spirit:range>            
                  <spirit:register>
                     <spirit:name>fix_ptp_violations</spirit:name>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000001</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>implemented</spirit:name>
                        <spirit:description>This is the synthesis parameter value used. When 1, it shows the PTP Guard fix logic has been implemented</spirit:description>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>activate</spirit:name>
                        <spirit:description>When 1, and if the fix logic is implemented, it instructs the PTP Guard to fix the PTP violations it detects (and reports). Note that there is a synthesis parameter to generate the "fix" logic or not

When 0, no attempt is done to fix (even if the logic exists) and the PTP Guard will only work as a monitor and reports the violations detected.

For full details of the operation, what violations are detected and fixed, and how the fix is done, see the wiki.</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>1</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80005168</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>max_cycles</spirit:name>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00030000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_mode</spirit:name>
                        <spirit:description>This configures the mode of counting towards max_cycles:

0x0: All PTP cycles are included in the count
0x1: PTP cycles with backpressure (drdy=1'b0) are excluded from the count
0x2: PTP cycles with wait (srdy=1'b0) are excluded from the count
0x3: PTP cycles with either backpressure or wait are excluded from the count. Hence, only "absorbed" PTP cycles are included in the count

Other mode values are reserved</spirit:description>
                        <spirit:bitOffset>16</spirit:bitOffset>
                        <spirit:bitWidth>4</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0011</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>max_cycles</spirit:name>
                        <spirit:description>Sets the maximum number of clock cycles the PTP packet can last between its sop and eop taking into account the max_cycle_mode

When set to 0, it instructs the logic not to fix this violation (when the fix logic is available). However, the monitor will still issue a violation when the cycle count reaches its maximum and rollover.</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x8000516C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80005168</address>
                        <context>ptp_guard_2core</context>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : config0  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                  <spirit:name>stats0</spirit:name>
                  <spirit:description>All the Statistic Registers and their configuration</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:range>0x10</spirit:range>            
                  <spirit:register>
                     <spirit:name>rd2clr_config</spirit:name>
                     <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_err</spirit:name>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_eop_err</spirit:name>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_sop_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80005170</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>missing_sop_err</spirit:name>
                     <spirit:description>Counts the number of PTP violations due to missing sop where the srdy was asserted without a prior sop assertion</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>missing_sop_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80005174</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>missing_eop_err</spirit:name>
                     <spirit:description>Counts the number of PTP violations due to missing eop where the PTP had been started but a new sop is seen without ending the previously started PTP</spirit:description>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>missing_eop_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80005178</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>max_cycle_err</spirit:name>
                     <spirit:description>Counts the number of PTP violations due to reaching the maximum allowed cycles after starting a new PTP</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x8000517C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80005170</address>
                        <context>ptp_guard_2core</context>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 

  <!-- reg group
                    :irq0  --> 
          <spirit:registerFile>
                  <spirit:name>irq0</spirit:name>
                  <spirit:description>Define the IRQ group</spirit:description>
                  <spirit:addressOffset>0x1C</spirit:addressOffset>
                  <spirit:range>0x10</spirit:range>            
                  <spirit:register>
                     <spirit:name>enable</spirit:name>
                     <spirit:description>The enable for the actual interrupt signals. Writing a 1 enables the interrupt.
</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_err</spirit:name>
                        <spirit:description>Fires on PTP violations due to reaching the maximum allowed cycles after starting a new PTP</spirit:description>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_eop_err</spirit:name>
                        <spirit:description>Fires on PTP violations due to missing eop where the PTP had been started but a new sop is seen without ending the previously started PTP</spirit:description>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_sop_err</spirit:name>
                        <spirit:description>Fires on PTP violations due to missing sop where the srdy was asserted without a prior sop assertion</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80005180</address>
                           <intr.enable>irq666_ptp_guard_2core</intr.enable>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>pending</spirit:name>
                     <spirit:description>The actual interrupt(s) that has triggered. Write a 1 to clear.
</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_err</spirit:name>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_eop_err</spirit:name>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_sop_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80005184</address>
                           <intr.status>irq666_ptp_guard_2core</intr.status>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>pending_irq</spirit:name>
                     <spirit:description>Registered version of pending &amp; enable.
</spirit:description>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_err</spirit:name>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_eop_err</spirit:name>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_sop_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80005188</address>
                           <intr.pending>irq666_ptp_guard_2core</intr.pending>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>raw</spirit:name>
                     <spirit:description>The status registered values for the interrupt signals, if applicable.</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_err</spirit:name>
                        <spirit:description>Not used</spirit:description>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_eop_err</spirit:name>
                        <spirit:description>Not used</spirit:description>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_sop_err</spirit:name>
                        <spirit:description>Not used</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x8000518C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80005180</address>
                        <context>ptp_guard_2core</context>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : irq0  --> 
<spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80005164</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : ptp_guard_2core  --> 

  <!-- reg group
                    :ptp_guard_2phy  --> 
          <spirit:registerFile>
               <spirit:name>ptp_guard_2phy</spirit:name>
               <spirit:addressOffset>0x90</spirit:addressOffset>
               <spirit:range>0x2C</spirit:range>            
               <spirit:register>
                  <spirit:name>version</spirit:name>
                  <spirit:description>3.1.0: Fixed bug in Max Cycle Error where in certain mode the cycles were included in the count
3.2.0: Changed the Interrupt Pending to avoid blocking the register update when enable is 0
3.3.0: Added pending_irq register</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00030300</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>major</spirit:name>
                     <spirit:description>Major version</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000011</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>minor</spirit:name>
                     <spirit:description>Minor version</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000011</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>patch</spirit:name>
                     <spirit:description>Patch version</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80005190</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
  <!-- reg group
                    :config0  --> 
          <spirit:registerFile>
                  <spirit:name>config0</spirit:name>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:range>0x8</spirit:range>            
                  <spirit:register>
                     <spirit:name>fix_ptp_violations</spirit:name>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000001</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>implemented</spirit:name>
                        <spirit:description>This is the synthesis parameter value used. When 1, it shows the PTP Guard fix logic has been implemented</spirit:description>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>activate</spirit:name>
                        <spirit:description>When 1, and if the fix logic is implemented, it instructs the PTP Guard to fix the PTP violations it detects (and reports). Note that there is a synthesis parameter to generate the "fix" logic or not

When 0, no attempt is done to fix (even if the logic exists) and the PTP Guard will only work as a monitor and reports the violations detected.

For full details of the operation, what violations are detected and fixed, and how the fix is done, see the wiki.</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>1</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80005194</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>max_cycles</spirit:name>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00030000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_mode</spirit:name>
                        <spirit:description>This configures the mode of counting towards max_cycles:

0x0: All PTP cycles are included in the count
0x1: PTP cycles with backpressure (drdy=1'b0) are excluded from the count
0x2: PTP cycles with wait (srdy=1'b0) are excluded from the count
0x3: PTP cycles with either backpressure or wait are excluded from the count. Hence, only "absorbed" PTP cycles are included in the count

Other mode values are reserved</spirit:description>
                        <spirit:bitOffset>16</spirit:bitOffset>
                        <spirit:bitWidth>4</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0011</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>max_cycles</spirit:name>
                        <spirit:description>Sets the maximum number of clock cycles the PTP packet can last between its sop and eop taking into account the max_cycle_mode

When set to 0, it instructs the logic not to fix this violation (when the fix logic is available). However, the monitor will still issue a violation when the cycle count reaches its maximum and rollover.</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80005198</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80005194</address>
                        <context>ptp_guard_2phy</context>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : config0  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                  <spirit:name>stats0</spirit:name>
                  <spirit:description>All the Statistic Registers and their configuration</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:range>0x10</spirit:range>            
                  <spirit:register>
                     <spirit:name>rd2clr_config</spirit:name>
                     <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_err</spirit:name>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_eop_err</spirit:name>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_sop_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x8000519C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>missing_sop_err</spirit:name>
                     <spirit:description>Counts the number of PTP violations due to missing sop where the srdy was asserted without a prior sop assertion</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>missing_sop_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x800051A0</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>missing_eop_err</spirit:name>
                     <spirit:description>Counts the number of PTP violations due to missing eop where the PTP had been started but a new sop is seen without ending the previously started PTP</spirit:description>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>missing_eop_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x800051A4</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>max_cycle_err</spirit:name>
                     <spirit:description>Counts the number of PTP violations due to reaching the maximum allowed cycles after starting a new PTP</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x800051A8</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000519C</address>
                        <context>ptp_guard_2phy</context>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 

  <!-- reg group
                    :irq0  --> 
          <spirit:registerFile>
                  <spirit:name>irq0</spirit:name>
                  <spirit:description>Define the IRQ group</spirit:description>
                  <spirit:addressOffset>0x1C</spirit:addressOffset>
                  <spirit:range>0x10</spirit:range>            
                  <spirit:register>
                     <spirit:name>enable</spirit:name>
                     <spirit:description>The enable for the actual interrupt signals. Writing a 1 enables the interrupt.
</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_err</spirit:name>
                        <spirit:description>Fires on PTP violations due to reaching the maximum allowed cycles after starting a new PTP</spirit:description>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_eop_err</spirit:name>
                        <spirit:description>Fires on PTP violations due to missing eop where the PTP had been started but a new sop is seen without ending the previously started PTP</spirit:description>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_sop_err</spirit:name>
                        <spirit:description>Fires on PTP violations due to missing sop where the srdy was asserted without a prior sop assertion</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x800051AC</address>
                           <intr.enable>irq666_ptp_guard_2phy</intr.enable>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>pending</spirit:name>
                     <spirit:description>The actual interrupt(s) that has triggered. Write a 1 to clear.
</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_err</spirit:name>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_eop_err</spirit:name>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_sop_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x800051B0</address>
                           <intr.status>irq666_ptp_guard_2phy</intr.status>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>pending_irq</spirit:name>
                     <spirit:description>Registered version of pending &amp; enable.
</spirit:description>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_err</spirit:name>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_eop_err</spirit:name>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_sop_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x800051B4</address>
                           <intr.pending>irq666_ptp_guard_2phy</intr.pending>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>raw</spirit:name>
                     <spirit:description>The status registered values for the interrupt signals, if applicable.</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_err</spirit:name>
                        <spirit:description>Not used</spirit:description>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_eop_err</spirit:name>
                        <spirit:description>Not used</spirit:description>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_sop_err</spirit:name>
                        <spirit:description>Not used</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x800051B8</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800051AC</address>
                        <context>ptp_guard_2phy</context>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : irq0  --> 
<spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80005190</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : ptp_guard_2phy  --> 

  <!-- reg group
                    :irq0  --> 
          <spirit:registerFile>
               <spirit:name>irq0</spirit:name>
               <spirit:description>Define the IRQ group</spirit:description>
               <spirit:addressOffset>0xBC</spirit:addressOffset>
               <spirit:range>0x10</spirit:range>            
               <spirit:register>
                  <spirit:name>enable</spirit:name>
                  <spirit:description>The enable for the actual interrupt signals. Writing a 1 enables the interrupt.
</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>core_clk_mode</spirit:name>
                     <spirit:description>Fires when the core clock mode changes from system 125 to the derivative of the PCLK (1/2PCLK) or vice-versa</spirit:description>
                     <spirit:bitOffset>29</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>u3_exit_completed</spirit:name>
                     <spirit:description>Fires when the U1/U2 or U3 wakeup is successfully complete</spirit:description>
                     <spirit:bitOffset>28</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>u3_as_slave_exit_failed</spirit:name>
                     <spirit:description>When Salve of exit, it fires on when U3 wakeup does not complete. This is typically is the case when the port is configured to not start its wakeup LFPS (delay t11 of Figure 6-30) before 10 ms limit.</spirit:description>
                     <spirit:bitOffset>27</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>u3_as_master_exit_failed</spirit:name>
                     <spirit:description>When Master of exit, it fires on when the U1/U2 exit or U3 wakeup does not complete correctly due to tNOLFPSReponseTimeout. 

--See Section 7.2.4.2.7 Item 5 and Item 6</spirit:description>
                     <spirit:bitOffset>26</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>u3_exit_initiated</spirit:name>
                     <spirit:description>Fires on when a U1/U2 exit or U3 wakeup is received</spirit:description>
                     <spirit:bitOffset>25</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_u3</spirit:name>
                     <spirit:description>Fires on when entered U3</spirit:description>
                     <spirit:bitOffset>24</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>u3_entry_failed</spirit:name>
                     <spirit:description>Fires on when our U3 does not complete and we end up in LTSSM Inactive. (NOT CONNECTED)

--see Section 7.2.4.2.4 Item 11</spirit:description>
                     <spirit:bitOffset>23</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>u3_entry_received</spirit:name>
                     <spirit:description>Fires on when a U3 Request is received from the USB partner
Note that only a downstream partner will issue U3</spirit:description>
                     <spirit:bitOffset>22</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_u2</spirit:name>
                     <spirit:description>Fires on when entered U2</spirit:description>
                     <spirit:bitOffset>21</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>u2_entry_rejected</spirit:name>
                     <spirit:description>Fires on when our U2 request is rejected by the USB partner</spirit:description>
                     <spirit:bitOffset>20</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>u2_entry_received</spirit:name>
                     <spirit:description>Fires on when a U2 Request is received from the USB partner</spirit:description>
                     <spirit:bitOffset>19</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_u1</spirit:name>
                     <spirit:description>Fires on when entered U1</spirit:description>
                     <spirit:bitOffset>18</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>u1_entry_rejected</spirit:name>
                     <spirit:description>Fires on when our U1 request is rejected by the USB partner</spirit:description>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>u1_entry_received</spirit:name>
                     <spirit:description>Fires on when a U1 Request is received from the USB partner</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>completed_hot_reset</spirit:name>
                     <spirit:description>Fires on completing the hot reset</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_hot_reset</spirit:name>
                     <spirit:description>Fires on entry into hot reset</spirit:description>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>completed_warm_reset</spirit:name>
                     <spirit:description>Fires on completing the warm reset</spirit:description>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_warm_reset</spirit:name>
                     <spirit:description>Fires on entry into warm reset</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_termination_det</spirit:name>
                     <spirit:description>Fires on changing the state of the USB partner's RX Termination</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>remote_rx_hdr_buff_crdt_cnt_in_err</spirit:name>
                     <spirit:description>Fires on Remote RX Header Buffer Credit Count erroneous increment or decrement</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lmp_rx_event_fifo_underflow</spirit:name>
                     <spirit:description>Fires on LMP Manager RX Event FIFO Underflow</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lmp_rx_event_fifo_overflow</spirit:name>
                     <spirit:description>Fires on LMP Manager RX Event FIFO Overflow</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>link_command_rx_event_fifo_underflow</spirit:name>
                     <spirit:description>Fires on Link Command RX Event FIFO Underflow</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>link_command_rx_event_fifo_overflow</spirit:name>
                     <spirit:description>Fires on Link Command RX Event FIFO Overflow</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lmp_ptp_violated</spirit:name>
                     <spirit:description>Fires on PTP Protocol Violation in the LMP Manager</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>link_command_ptp_violated</spirit:name>
                     <spirit:description>Fires on PTP Protocol Violation in the Link Command Manager</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>link_training_ptp_violated</spirit:name>
                     <spirit:description>Fires on PTP Protocol Violation in the Link Training Manager</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_framer_ptp_violated</spirit:name>
                     <spirit:description>Fires on PTP Protocol Violation in the TX Frame Manager</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_lfps_cnt_in_err</spirit:name>
                     <spirit:description>Fires on RX LFPS counter going beyond the largest value possible</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_lfps_cnt_in_err</spirit:name>
                     <spirit:description>Fires on TX LFPS counter going beyond the largest value possible</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800051BC</address>
                        <intr.enable>irq0_ulp_core</intr.enable>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending</spirit:name>
                  <spirit:description>The actual interrupt(s) that has triggered. Write a 1 to clear.
</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>core_clk_mode</spirit:name>
                     <spirit:description>Fires when the core clock mode changes from system 125 to the derivative of the PCLK (1/2PCLK) or vice-versa</spirit:description>
                     <spirit:bitOffset>29</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>u3_exit_completed</spirit:name>
                     <spirit:description>Fires when the U1/U2 or U3 wakeup is successfully complete</spirit:description>
                     <spirit:bitOffset>28</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>u3_as_slave_exit_failed</spirit:name>
                     <spirit:description>When Salve of exit, it fires on when U3 wakeup does not complete. This is typically is the case when the port is configured to not start its wakeup LFPS (delay t11 of Figure 6-30) before 10 ms limit.</spirit:description>
                     <spirit:bitOffset>27</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>u3_as_master_exit_failed</spirit:name>
                     <spirit:description>When Master of exit, it fires on when the U1/U2 exit or U3 wakeup does not complete correctly due to tNOLFPSReponseTimeout. 

--See Section 7.2.4.2.7 Item 5 and Item 6</spirit:description>
                     <spirit:bitOffset>26</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>u3_exit_initiated</spirit:name>
                     <spirit:description>Fires on when a U1/U2 exit or U3 wakeup is received</spirit:description>
                     <spirit:bitOffset>25</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_u3</spirit:name>
                     <spirit:description>Fires on when entered U3</spirit:description>
                     <spirit:bitOffset>24</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>u3_entry_failed</spirit:name>
                     <spirit:description>Fires on when our U3 does not complete and we end up in LTSSM Inactive 
--see Section 7.2.4.2.4 Item 11</spirit:description>
                     <spirit:bitOffset>23</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>u3_entry_received</spirit:name>
                     <spirit:description>Fires on when a U3 Request is received from the USB partner
Note that only a downstream partner will issue U3</spirit:description>
                     <spirit:bitOffset>22</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_u2</spirit:name>
                     <spirit:description>Fires on when entered U2</spirit:description>
                     <spirit:bitOffset>21</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>u2_entry_rejected</spirit:name>
                     <spirit:description>Fires on when our U2 request is rejected by the USB partner</spirit:description>
                     <spirit:bitOffset>20</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>u2_entry_received</spirit:name>
                     <spirit:description>Fires on when a U2 Request is received from the USB partner</spirit:description>
                     <spirit:bitOffset>19</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_u1</spirit:name>
                     <spirit:description>Fires on when entered U1</spirit:description>
                     <spirit:bitOffset>18</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>u1_entry_rejected</spirit:name>
                     <spirit:description>Fires on when our U1 request is rejected by the USB partner</spirit:description>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>u1_entry_received</spirit:name>
                     <spirit:description>Fires on when a U1 Request is received from the USB partner</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>completed_hot_reset</spirit:name>
                     <spirit:description>Fires on completing the hot reset</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_hot_reset</spirit:name>
                     <spirit:description>Fires on entry into hot reset</spirit:description>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>completed_warm_reset</spirit:name>
                     <spirit:description>Fires on completing the warm reset</spirit:description>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_warm_reset</spirit:name>
                     <spirit:description>Fires on entry into warm reset</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_termination_det</spirit:name>
                     <spirit:description>Fires on changing the state of the USB partner's RX Termination</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>remote_rx_hdr_buff_crdt_cnt_in_err</spirit:name>
                     <spirit:description>Fires on Remote RX Header Buffer Credit Count erroneous increment or decrement</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lmp_rx_event_fifo_underflow</spirit:name>
                     <spirit:description>Fires on LMP Manager RX Event FIFO Underflow</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lmp_rx_event_fifo_overflow</spirit:name>
                     <spirit:description>Fires on LMP Manager RX Event FIFO Overflow</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>link_command_rx_event_fifo_underflow</spirit:name>
                     <spirit:description>Fires on Link Command RX Event FIFO Underflow</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>link_command_rx_event_fifo_overflow</spirit:name>
                     <spirit:description>Fires on Link Command RX Event FIFO Overflow</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lmp_ptp_violated</spirit:name>
                     <spirit:description>Fires on PTP Protocol Violation in the LMP Manager</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>link_command_ptp_violated</spirit:name>
                     <spirit:description>Fires on PTP Protocol Violation in the Link Command Manager</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>link_training_ptp_violated</spirit:name>
                     <spirit:description>Fires on PTP Protocol Violation in the Link Training Manager</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_framer_ptp_violated</spirit:name>
                     <spirit:description>Fires on PTP Protocol Violation in the TX Frame Manager</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_lfps_cnt_in_err</spirit:name>
                     <spirit:description>Fires on RX LFPS counter going beyond the largest value possible</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_lfps_cnt_in_err</spirit:name>
                     <spirit:description>Fires on TX LFPS counter going beyond the largest value possible</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800051C0</address>
                        <intr.status>irq0_ulp_core</intr.status>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending_irq</spirit:name>
                  <spirit:description>Registered version of pending &amp; enable
</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>core_clk_mode</spirit:name>
                     <spirit:description>Fires when the core clock mode changes from system 125 to the derivative of the PCLK (1/2PCLK) or vice-versa</spirit:description>
                     <spirit:bitOffset>29</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>u3_exit_completed</spirit:name>
                     <spirit:description>Fires when the U1/U2 or U3 wakeup is successfully complete</spirit:description>
                     <spirit:bitOffset>28</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>u3_as_slave_exit_failed</spirit:name>
                     <spirit:description>When Salve of exit, it fires on when U3 wakeup does not complete. This is typically is the case when the port is configured to not start its wakeup LFPS (delay t11 of Figure 6-30) before 10 ms limit.</spirit:description>
                     <spirit:bitOffset>27</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>u3_as_master_exit_failed</spirit:name>
                     <spirit:description>When Master of exit, it fires on when the U1/U2 exit or U3 wakeup does not complete correctly due to tNOLFPSReponseTimeout. 

--See Section 7.2.4.2.7 Item 5 and Item 6</spirit:description>
                     <spirit:bitOffset>26</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>u3_exit_initiated</spirit:name>
                     <spirit:description>Fires on when a U1/U2 exit or U3 wakeup is received</spirit:description>
                     <spirit:bitOffset>25</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_u3</spirit:name>
                     <spirit:description>Fires on when entered U3</spirit:description>
                     <spirit:bitOffset>24</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>u3_entry_failed</spirit:name>
                     <spirit:description>Fires on when our U3 does not complete and we end up in LTSSM Inactive 
--see Section 7.2.4.2.4 Item 11</spirit:description>
                     <spirit:bitOffset>23</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>u3_entry_received</spirit:name>
                     <spirit:description>Fires on when a U3 Request is received from the USB partner
Note that only a downstream partner will issue U3</spirit:description>
                     <spirit:bitOffset>22</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_u2</spirit:name>
                     <spirit:description>Fires on when entered U2</spirit:description>
                     <spirit:bitOffset>21</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>u2_entry_rejected</spirit:name>
                     <spirit:description>Fires on when our U2 request is rejected by the USB partner</spirit:description>
                     <spirit:bitOffset>20</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>u2_entry_received</spirit:name>
                     <spirit:description>Fires on when a U2 Request is received from the USB partner</spirit:description>
                     <spirit:bitOffset>19</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_u1</spirit:name>
                     <spirit:description>Fires on when entered U1</spirit:description>
                     <spirit:bitOffset>18</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>u1_entry_rejected</spirit:name>
                     <spirit:description>Fires on when our U1 request is rejected by the USB partner</spirit:description>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>u1_entry_received</spirit:name>
                     <spirit:description>Fires on when a U1 Request is received from the USB partner</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>completed_hot_reset</spirit:name>
                     <spirit:description>Fires on completing the hot reset</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_hot_reset</spirit:name>
                     <spirit:description>Fires on entry into hot reset</spirit:description>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>completed_warm_reset</spirit:name>
                     <spirit:description>Fires on completing the warm reset</spirit:description>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_warm_reset</spirit:name>
                     <spirit:description>Fires on entry into warm reset</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_termination_det</spirit:name>
                     <spirit:description>Fires on changing the state of the USB partner's RX Termination</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>remote_rx_hdr_buff_crdt_cnt_in_err</spirit:name>
                     <spirit:description>Fires on Remote RX Header Buffer Credit Count erroneous increment or decrement</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lmp_rx_event_fifo_underflow</spirit:name>
                     <spirit:description>Fires on LMP Manager RX Event FIFO Underflow</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lmp_rx_event_fifo_overflow</spirit:name>
                     <spirit:description>Fires on LMP Manager RX Event FIFO Overflow</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>link_command_rx_event_fifo_underflow</spirit:name>
                     <spirit:description>Fires on Link Command RX Event FIFO Underflow</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>link_command_rx_event_fifo_overflow</spirit:name>
                     <spirit:description>Fires on Link Command RX Event FIFO Overflow</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lmp_ptp_violated</spirit:name>
                     <spirit:description>Fires on PTP Protocol Violation in the LMP Manager</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>link_command_ptp_violated</spirit:name>
                     <spirit:description>Fires on PTP Protocol Violation in the Link Command Manager</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>link_training_ptp_violated</spirit:name>
                     <spirit:description>Fires on PTP Protocol Violation in the Link Training Manager</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_framer_ptp_violated</spirit:name>
                     <spirit:description>Fires on PTP Protocol Violation in the TX Frame Manager</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_lfps_cnt_in_err</spirit:name>
                     <spirit:description>Fires on RX LFPS counter going beyond the largest value possible</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_lfps_cnt_in_err</spirit:name>
                     <spirit:description>Fires on TX LFPS counter going beyond the largest value possible</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800051C4</address>
                        <intr.pending>irq0_ulp_core</intr.pending>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>raw</spirit:name>
                  <spirit:description>The status registered values for the interrupt signals, if applicable.</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>core_clk_mode</spirit:name>
                     <spirit:description>Shows the status of the clock source for the ULP core.
When 0, the source is from system 125
When 1, it is the 125 derived from the PCLK (250)</spirit:description>
                     <spirit:bitOffset>29</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>u3_exit_completed</spirit:name>
                     <spirit:description>Not used</spirit:description>
                     <spirit:bitOffset>28</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>u3_as_slave_exit_failed</spirit:name>
                     <spirit:description>Not used</spirit:description>
                     <spirit:bitOffset>27</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>u3_as_master_exit_failed</spirit:name>
                     <spirit:description>Not used</spirit:description>
                     <spirit:bitOffset>26</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>u3_exit_initiated</spirit:name>
                     <spirit:description>Not used</spirit:description>
                     <spirit:bitOffset>25</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_u3</spirit:name>
                     <spirit:description>Not used</spirit:description>
                     <spirit:bitOffset>24</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>u3_entry_failed</spirit:name>
                     <spirit:description>Not used</spirit:description>
                     <spirit:bitOffset>23</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>u3_entry_received</spirit:name>
                     <spirit:description>Not used</spirit:description>
                     <spirit:bitOffset>22</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_u2</spirit:name>
                     <spirit:description>Not used</spirit:description>
                     <spirit:bitOffset>21</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>u2_entry_rejected</spirit:name>
                     <spirit:description>Not used</spirit:description>
                     <spirit:bitOffset>20</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>u2_entry_received</spirit:name>
                     <spirit:description>Not used</spirit:description>
                     <spirit:bitOffset>19</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_u1</spirit:name>
                     <spirit:description>Not used</spirit:description>
                     <spirit:bitOffset>18</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>u1_entry_rejected</spirit:name>
                     <spirit:description>Not used</spirit:description>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>u1_entry_received</spirit:name>
                     <spirit:description>Not used</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>completed_hot_reset</spirit:name>
                     <spirit:description>Not used</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_hot_reset</spirit:name>
                     <spirit:description>Not used</spirit:description>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>completed_warm_reset</spirit:name>
                     <spirit:description>Not used</spirit:description>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_warm_reset</spirit:name>
                     <spirit:description>Not used</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_termination_det</spirit:name>
                     <spirit:description>Shows the status of the USB partner's RX Termination. When 1, the termination has been detected. When 0, no termination detected</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>remote_rx_hdr_buff_crdt_cnt_in_err</spirit:name>
                     <spirit:description>Not used</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lmp_rx_event_fifo_underflow</spirit:name>
                     <spirit:description>Not used</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lmp_rx_event_fifo_overflow</spirit:name>
                     <spirit:description>Not used</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>link_command_rx_event_fifo_underflow</spirit:name>
                     <spirit:description>Not used</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>link_command_rx_event_fifo_overflow</spirit:name>
                     <spirit:description>Not used</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lmp_ptp_violated</spirit:name>
                     <spirit:description>Not used</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>link_command_ptp_violated</spirit:name>
                     <spirit:description>Not used</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>link_training_ptp_violated</spirit:name>
                     <spirit:description>Not used</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_framer_ptp_violated</spirit:name>
                     <spirit:description>Not used</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_lfps_cnt_in_err</spirit:name>
                     <spirit:description>Not used</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_lfps_cnt_in_err</spirit:name>
                     <spirit:description>Not used</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800051C8</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x800051BC</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : irq0  --> 

  <!-- reg group
                    :irq1  --> 
          <spirit:registerFile>
               <spirit:name>irq1</spirit:name>
               <spirit:description>Define the IRQ group</spirit:description>
               <spirit:addressOffset>0xCC</spirit:addressOffset>
               <spirit:range>0x10</spirit:range>            
               <spirit:register>
                  <spirit:name>enable</spirit:name>
                  <spirit:description>The enable for the actual interrupt signals. Writing a 1 enables the interrupt.
</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>in_recovery</spirit:name>
                     <spirit:description>Fires on entering into LTSSM Recovery</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_loopback</spirit:name>
                     <spirit:description>Fires on entering into LTSSM Loopback</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_compliance</spirit:name>
                     <spirit:description>Fires on entering into LTSSM Compliance Mode</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_disabled</spirit:name>
                     <spirit:description>Fires on entering into LTSSM eSS.Disabled</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_u0</spirit:name>
                     <spirit:description>Fires on entering into LTSSM U0</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_polling</spirit:name>
                     <spirit:description>Fires on entering into LTSSM Polling</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_rx_detect</spirit:name>
                     <spirit:description>Fires on entering into LTSSM RX.Detect</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_inactive</spirit:name>
                     <spirit:description>Fires on entering into LTSSM eSS.Inactive</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800051CC</address>
                        <intr.enable>irq1_ulp_core</intr.enable>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending</spirit:name>
                  <spirit:description>The actual interrupt(s) that has triggered. Write a 1 to clear.
</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>in_recovery</spirit:name>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_loopback</spirit:name>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_compliance</spirit:name>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_disabled</spirit:name>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_u0</spirit:name>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_polling</spirit:name>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_rx_detect</spirit:name>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_inactive</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800051D0</address>
                        <intr.status>irq1_ulp_core</intr.status>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending_irq</spirit:name>
                  <spirit:description>Registered version of pending &amp; enable
</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>in_recovery</spirit:name>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_loopback</spirit:name>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_compliance</spirit:name>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_disabled</spirit:name>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_u0</spirit:name>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_polling</spirit:name>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_rx_detect</spirit:name>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_inactive</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800051D4</address>
                        <intr.pending>irq1_ulp_core</intr.pending>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>raw</spirit:name>
                  <spirit:description>The status registered values for the interrupt signals, if applicable.</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>in_recovery</spirit:name>
                     <spirit:description>Fires on entering into LTSSM Recovery</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_loopback</spirit:name>
                     <spirit:description>Fires on entering into LTSSM Loopback</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_compliance</spirit:name>
                     <spirit:description>Fires on entering into LTSSM Compliance Mode</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_disabled</spirit:name>
                     <spirit:description>Fires on entering into LTSSM eSS.Disabled</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_u0</spirit:name>
                     <spirit:description>Fires on entering into LTSSM U0</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_polling</spirit:name>
                     <spirit:description>Fires on entering into LTSSM Polling</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_rx_detect</spirit:name>
                     <spirit:description>Fires on entering into LTSSM RX.Detect</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_inactive</spirit:name>
                     <spirit:description>Fires on entering into LTSSM eSS.Inactive</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800051D8</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x800051CC</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : irq1  --> 
         <spirit:vendorExtensions>
               <ids_properties>
                  <module_name>ulp_core_regs</module_name>
                  <uvm.package>ulp_core_regs_pkg</uvm.package>
                  <reset_type>async</reset_type>
                  <cheader.mask_endianess>little</cheader.mask_endianess>
                  <header.struct_guard>__ASSEMBLER__</header.struct_guard>
                  <explicit_name>true</explicit_name>
                  <vertical_reuse>true</vertical_reuse>
                  <address>0x80005100</address>
               </ids_properties>
            </spirit:vendorExtensions>
         </spirit:addressBlock>     
         <spirit:addressBlock>     
            <spirit:name>ulp_phy</spirit:name>
            <spirit:description>All Registers in the PHY clock domain (250MHz)

</spirit:description>  <!-- //
                        block : ulp_phy  --> 
            <spirit:baseAddress>0x80005300</spirit:baseAddress>               
            <spirit:range>0x100</spirit:range>               
            <spirit:width>32</spirit:width>            
            <spirit:register>
               <spirit:name>version</spirit:name>
               <spirit:description>3.1.0: Changed the Interrupt Pending to avoid blocking the register update when enable is 0
3.2.0: Added pending_irq register</spirit:description>
               <spirit:addressOffset>0x0</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00030200</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>major</spirit:name>
                  <spirit:description>Major version</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000011</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>minor</spirit:name>
                  <spirit:description>Minor version</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000010</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>patch</spirit:name>
                  <spirit:description>Patch version</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80005300</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>pipe_ctrl</spirit:name>
               <spirit:addressOffset>0x4</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000010</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>tx_swing</spirit:name>
                  <spirit:description>TX Voltage Swing Level (0=Full, 1=Low)
-See PIPE Spec V3.0 Table 5-3</spirit:description>
                  <spirit:bitOffset>12</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>tx_margin</spirit:name>
                  <spirit:description>TX Voltage Level (0=Normal Operating Range)
-See PIPE Spec V3.0 Table 5-3</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>3</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>tx_deemph</spirit:name>
                  <spirit:description>TX De-emphasis (0=-6dB, 1=-3.5dB, 2=No De-Emphasis, 3=Reserved 
-See PIPE Spec V3.0 Table 5-3</spirit:description>
                  <spirit:bitOffset>4</spirit:bitOffset>
                  <spirit:bitWidth>2</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>01</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>reset_n</spirit:name>
                  <spirit:description>Resets the TX and RX (***NOTE USED NOW. PLACE HOLDER FOR LATER)
-See PIPE Spec V3.0 Table 5-3</spirit:description>
                  <spirit:bitOffset>2</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>rx_eq_training</spirit:name>
                  <spirit:description>Instructs the RX to bypass normal operation to perform equalization training 
-See PIPE Spec V3.0 Table 5-3</spirit:description>
                  <spirit:bitOffset>1</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>elas_buf_mode</spirit:name>
                  <spirit:description>Elasticity Buffer Mode (Nominal Half Full when 0 and Nominal Empty when 1) 
-See PIPE Spec V3.0 Table 5-3</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80005304</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>compliancy_ctrl</spirit:name>
               <spirit:description>Provides manual access to do the compliancy testing if needed and the right hardware is not available</spirit:description>
               <spirit:addressOffset>0x8</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>gen_lfps_ping</spirit:name>
                  <spirit:description>When set, it signals an LFPS ping has been received in the compliancy logic forcing the next compliancy pattern

Write a 1 and HW clears it when completed the action
</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                     <ids_properties>
                        <rtl.hw_clear>true</rtl.hw_clear>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80005308</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>
  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
               <spirit:name>stats0</spirit:name>
               <spirit:description>All the Statistic Registers and their configuration for the ULP PHY Stats</spirit:description>
               <spirit:addressOffset>0xC</spirit:addressOffset>
               <spirit:range>0x14</spirit:range>            
               <spirit:register>
                  <spirit:name>rd2clr_config</spirit:name>
                  <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>rx_disparity_err</spirit:name>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_elastic_buff_underflow</spirit:name>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_elastic_buff_overflow</spirit:name>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_8b10b_err</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x8000530C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>rx_8b10b_err</spirit:name>
                  <spirit:description>Count of the 8B/10B decoder error in the PHY RX. This is based on the encoding of RxStatus[2:0] in the PIPE Standard</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>rx_8b10b_err</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80005310</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>rx_elastic_buff_overflow</spirit:name>
                  <spirit:description>Count of the Elastic Buffer Overflows in the PHY RX. This is based on the encoding of RxStatus[2:0] in the PIPE Standard</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>rx_elastic_buff_overflow</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80005314</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>rx_elastic_buff_underflow</spirit:name>
                  <spirit:description>Count of the Elastic Buffer Underflows in the PHY RX. This is based on the encoding of RxStatus[2:0] in the PIPE Standard</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>rx_elastic_buff_underflow</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80005318</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>rx_disparity_err</spirit:name>
                  <spirit:description>Count of the Disparity error in the PHY RX. This is based on the encoding of RxStatus[2:0] in the PIPE Standard</spirit:description>
                  <spirit:addressOffset>0x10</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>rx_disparity_err</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x8000531C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x8000530C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 

  <!-- reg group
                    :stats1  --> 
          <spirit:registerFile>
               <spirit:name>stats1</spirit:name>
               <spirit:description>All the Statistic Registers and their configuration for the ULP logic</spirit:description>
               <spirit:addressOffset>0x20</spirit:addressOffset>
               <spirit:range>0x18</spirit:range>            
               <spirit:register>
                  <spirit:name>rd2clr_config</spirit:name>
                  <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>rx_framer_ptp_violated</spirit:name>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dpp_abort</spirit:name>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>crc16_chk_failed</spirit:name>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>crc5_chk_failed</spirit:name>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>skp_insert_in_err</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80005320</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>skp_insert_in_err</spirit:name>
                  <spirit:description>Count the number of the erroneous skip injection</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>skp_insert_in_err</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80005324</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>crc5_chk_failed</spirit:name>
                  <spirit:description>Count the number of detected crc5 errors</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>crc5_chk_failed</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80005328</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>crc16_chk_failed</spirit:name>
                  <spirit:description>Count the number of detected crc16 errors</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>crc16_chk_failed</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x8000532C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>dpp_abort</spirit:name>
                  <spirit:description>Count the number of DPP abort symbols received in a Transaction Packet</spirit:description>
                  <spirit:addressOffset>0x10</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>dpp_abort</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80005330</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>rx_framer_ptp_violated</spirit:name>
                  <spirit:description>Count the number of PTP Protocol Violation in the RX Frame Manager</spirit:description>
                  <spirit:addressOffset>0x14</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>rx_framer_ptp_violated</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80005334</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80005320</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : stats1  --> 

  <!-- reg group
                    :irq0  --> 
          <spirit:registerFile>
               <spirit:name>irq0</spirit:name>
               <spirit:description>Define the IRQ group</spirit:description>
               <spirit:addressOffset>0x38</spirit:addressOffset>
               <spirit:range>0x10</spirit:range>            
               <spirit:register>
                  <spirit:name>enable</spirit:name>
                  <spirit:description>These are enable for the actual interrupt signals
</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>rx_framer_ptp_violated</spirit:name>
                     <spirit:description>Fires on PTP Protocol Violation in the RX Frame Manager</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dpp_abort</spirit:name>
                     <spirit:description>Fires on DPP abort symbols received in a Transaction Packet</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>crc16_chk_failed</spirit:name>
                     <spirit:description>Fires on detected crc16 errors</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>crc5_chk_failed</spirit:name>
                     <spirit:description>Fires on detected crc5 errors</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>skp_insert_in_err</spirit:name>
                     <spirit:description>Fires on erroneous skip injection</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80005338</address>
                        <intr.enable>irq0_ulp_phy</intr.enable>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending</spirit:name>
                  <spirit:description>The actual interrupt singal
</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>rx_framer_ptp_violated</spirit:name>
                     <spirit:description>Fires on PTP Protocol Violation in the RX Frame Manager</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dpp_abort</spirit:name>
                     <spirit:description>Fires on DPP abort symbols received in a Transaction Packet</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>crc16_chk_failed</spirit:name>
                     <spirit:description>Fires on detected crc16 errors</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>crc5_chk_failed</spirit:name>
                     <spirit:description>Fires on detected crc5 errors</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>skp_insert_in_err</spirit:name>
                     <spirit:description>Fires on erroneous skip injection</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000533C</address>
                        <intr.status>irq0_ulp_phy</intr.status>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending_irq</spirit:name>
                  <spirit:description>Registered version of pending &amp; enable
</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>rx_framer_ptp_violated</spirit:name>
                     <spirit:description>Fires on PTP Protocol Violation in the RX Frame Manager</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dpp_abort</spirit:name>
                     <spirit:description>Fires on DPP abort symbols received in a Transaction Packet</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>crc16_chk_failed</spirit:name>
                     <spirit:description>Fires on detected crc16 errors</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>crc5_chk_failed</spirit:name>
                     <spirit:description>Fires on detected crc5 errors</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>skp_insert_in_err</spirit:name>
                     <spirit:description>Fires on erroneous skip injection</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80005340</address>
                        <intr.pending>irq0_ulp_phy</intr.pending>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>raw</spirit:name>
                  <spirit:description>The Raw value for the interrupt signals</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>rx_framer_ptp_violated</spirit:name>
                     <spirit:description>Fires on PTP Protocol Violation in the RX Frame Manager</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dpp_abort</spirit:name>
                     <spirit:description>Fires on DPP abort symbols received in a Transaction Packet</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>crc16_chk_failed</spirit:name>
                     <spirit:description>Fires on detected crc16 errors</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>crc5_chk_failed</spirit:name>
                     <spirit:description>Fires on detected crc5 errors</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>skp_insert_in_err</spirit:name>
                     <spirit:description>Fires on erroneous skip injection</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80005344</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80005338</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : irq0  --> 
         <spirit:vendorExtensions>
               <ids_properties>
                  <module_name>ulp_phy_regs</module_name>
                  <uvm.package>ulp_phy_regs_pkg</uvm.package>
                  <reset_type>async</reset_type>
                  <cheader.mask_endianess>little</cheader.mask_endianess>
                  <header.struct_guard>__ASSEMBLER__</header.struct_guard>
                  <explicit_name>true</explicit_name>
                  <vertical_reuse>true</vertical_reuse>
                  <address>0x80005300</address>
               </ids_properties>
            </spirit:vendorExtensions>
         </spirit:addressBlock>
         <spirit:addressUnitBits>8</spirit:addressUnitBits>
         <spirit:vendorExtensions>
            <variants>
               <variant name="none" isselected="true">
                  <doc>'none' variant states including all templates which are not assigned any variant property.</doc>
               </variant>
            </variants>
            <ids:type>true</ids:type>
         </spirit:vendorExtensions>
      </spirit:memoryMap>
   </spirit:memoryMaps>
   <spirit:model>
      <spirit:ports>
         <spirit:port>
            <spirit:name>pclk</spirit:name>
            <spirit:wire>
               <spirit:direction>in</spirit:direction>
            </spirit:wire>
         </spirit:port>
         <spirit:port>
            <spirit:name>presetn</spirit:name>
            <spirit:wire>
               <spirit:direction>in</spirit:direction>
            </spirit:wire>
         </spirit:port>
         <spirit:port>
            <spirit:name>psel</spirit:name>
            <spirit:wire>
               <spirit:direction>in</spirit:direction>
            </spirit:wire>
         </spirit:port>
         <spirit:port>
            <spirit:name>penable</spirit:name>
            <spirit:wire>
               <spirit:direction>in</spirit:direction>
            </spirit:wire>
         </spirit:port>
         <spirit:port>
            <spirit:name>pwrite</spirit:name>
            <spirit:wire>
               <spirit:direction>in</spirit:direction>
            </spirit:wire>
         </spirit:port>
         <spirit:port>
            <spirit:name>pprot</spirit:name>
            <spirit:wire>
               <spirit:direction>in</spirit:direction>
               <spirit:vector>
                  <spirit:left>2</spirit:left>
                  <spirit:right>0</spirit:right>
               </spirit:vector>
            </spirit:wire>
         </spirit:port>
         <spirit:port>
            <spirit:name>pstrb</spirit:name>
            <spirit:wire>
               <spirit:direction>in</spirit:direction>
               <spirit:vector>
                  <spirit:left spirit:resolve="dependent"
                               spirit:dependency="(spirit:decode(id('MODELPARAM_VALUE.bus_width')) div 8 )-1">31</spirit:left>
                  <spirit:right>0</spirit:right>
               </spirit:vector>
            </spirit:wire>
         </spirit:port>
         <spirit:port>
            <spirit:name>pwdata</spirit:name>
            <spirit:wire>
               <spirit:direction>in</spirit:direction>
               <spirit:vector>
                  <spirit:left spirit:resolve="dependent"
                               spirit:dependency="spirit:decode(id('MODELPARAM_VALUE.bus_width')) -1">31</spirit:left>
                  <spirit:right>0</spirit:right>
               </spirit:vector>
            </spirit:wire>
         </spirit:port>
         <spirit:port>
            <spirit:name>paddr</spirit:name>
            <spirit:wire>
               <spirit:direction>in</spirit:direction>
               <spirit:vector>
                  <spirit:left spirit:resolve="dependent"
                               spirit:dependency="spirit:decode(id('MODELPARAM_VALUE.addr_width')) -1">3</spirit:left>
                  <spirit:right>0</spirit:right>
               </spirit:vector>
            </spirit:wire>
         </spirit:port>
         <spirit:port>
            <spirit:name>pready</spirit:name>
            <spirit:wire>
               <spirit:direction>out</spirit:direction>
            </spirit:wire>
         </spirit:port>
         <spirit:port>
            <spirit:name>prdata</spirit:name>
            <spirit:wire>
               <spirit:direction>out</spirit:direction>
               <spirit:vector>
                  <spirit:left spirit:resolve="dependent"
                               spirit:dependency="spirit:decode(id('MODELPARAM_VALUE.bus_width')) -1">31</spirit:left>
                  <spirit:right>0</spirit:right>
               </spirit:vector>
            </spirit:wire>
         </spirit:port>
         <spirit:port>
            <spirit:name>pslverr</spirit:name>
            <spirit:wire>
               <spirit:direction>out</spirit:direction>
            </spirit:wire>
         </spirit:port>
      </spirit:ports>
      <spirit:modelParameters>
         <spirit:modelParameter spirit:dataType="integer">
            <spirit:name>addr_width</spirit:name>
            <spirit:value spirit:id="MODELPARAM_VALUE.addr_width" spirit:resolve="user">28</spirit:value>
         </spirit:modelParameter>
         <spirit:modelParameter spirit:dataType="integer">
            <spirit:name>bus_width</spirit:name>
            <spirit:value spirit:id="MODELPARAM_VALUE.bus_width" spirit:resolve="user">32</spirit:value>
         </spirit:modelParameter>
      </spirit:modelParameters>
   </spirit:model>
   <spirit:vendorExtensions>
      <ids:type>false</ids:type>
   </spirit:vendorExtensions>
</spirit:component>