<?xml version="1.0" encoding="ISO-8859-1"?>
 <!-- created by        : Remco van Steeden -->
 <!-- generated by      : Remco.vanSteeden -->
 <!-- generated from    : C:\cygwin64\home\Remco.VanSteeden\blackbird_rls_20191024\f_blackbird_a7_core\regs\ids\bb_chip\bb_chip_regs.docx -->
 <!-- IDesignSpec rev   : 6.8.10.0 -->
 <!-- XML Revision      : $Revision: 1.100 $ -->

 <!-- *** This code is generated with following settings *** -->
 <!--  Reg Width                  : 32 -->
 <!--  Address Unit               : 8 -->
 <!--  C++ Types int              : uint%d_t -->
 <!--  Bus Type                   : APB -->
 <!--  BigEndian                  : true -->
 <!--  LittleEndian               : true -->
 <!--  Dist. Decode and Readback  : false -->
 <!--  ****************************************************** -->

<spirit:component xmlns:ids="http://www.agnisys.com/" xmlns:snps="http://www.synopsys.com/"
                  xmlns:xrsl="http://www.agnisys.com/"
                  xmlns:spirit="http://www.spiritconsortium.org/XMLSchema/SPIRIT/1685-2009">
   <spirit:vendor>IcronTechnologies</spirit:vendor>
   <spirit:library>IcronTechnologies</spirit:library>
   <spirit:name>bb_chip_model</spirit:name>
   <spirit:version>1.0</spirit:version>
   <spirit:busInterfaces>
      <spirit:busInterface>
         <spirit:name>default_map</spirit:name>
         <spirit:busType spirit:vendor="AGNISYS" spirit:library="AGNISYS" spirit:name="APB"
                         spirit:version="1.0"/>
         <spirit:abstractionType spirit:vendor="AGNISYS" spirit:library="AGNISYS" spirit:name="APB_rtl"
                                 spirit:version="1.0"/>
         <spirit:slave>
            <spirit:memoryMapRef spirit:memoryMapRef="bb_chip"/>
         </spirit:slave>
         <spirit:portMaps>
            <spirit:portMap>
               <spirit:logicalPort>
                  <spirit:name>pclk</spirit:name>
               </spirit:logicalPort>
               <spirit:physicalPort>
                  <spirit:name>pclk</spirit:name>
               </spirit:physicalPort>
            </spirit:portMap>
            <spirit:portMap>
               <spirit:logicalPort>
                  <spirit:name>presetn</spirit:name>
               </spirit:logicalPort>
               <spirit:physicalPort>
                  <spirit:name>presetn</spirit:name>
               </spirit:physicalPort>
            </spirit:portMap>
            <spirit:portMap>
               <spirit:logicalPort>
                  <spirit:name>psel</spirit:name>
               </spirit:logicalPort>
               <spirit:physicalPort>
                  <spirit:name>psel</spirit:name>
               </spirit:physicalPort>
            </spirit:portMap>
            <spirit:portMap>
               <spirit:logicalPort>
                  <spirit:name>penable</spirit:name>
               </spirit:logicalPort>
               <spirit:physicalPort>
                  <spirit:name>penable</spirit:name>
               </spirit:physicalPort>
            </spirit:portMap>
            <spirit:portMap>
               <spirit:logicalPort>
                  <spirit:name>pwrite</spirit:name>
               </spirit:logicalPort>
               <spirit:physicalPort>
                  <spirit:name>pwrite</spirit:name>
               </spirit:physicalPort>
            </spirit:portMap>
            <spirit:portMap>
               <spirit:logicalPort>
                  <spirit:name>pprot</spirit:name>
               </spirit:logicalPort>
               <spirit:physicalPort>
                  <spirit:name>pprot</spirit:name>
               </spirit:physicalPort>
            </spirit:portMap>
            <spirit:portMap>
               <spirit:logicalPort>
                  <spirit:name>pstrb</spirit:name>
               </spirit:logicalPort>
               <spirit:physicalPort>
                  <spirit:name>pstrb</spirit:name>
               </spirit:physicalPort>
            </spirit:portMap>
            <spirit:portMap>
               <spirit:logicalPort>
                  <spirit:name>pwdata</spirit:name>
               </spirit:logicalPort>
               <spirit:physicalPort>
                  <spirit:name>pwdata</spirit:name>
               </spirit:physicalPort>
            </spirit:portMap>
            <spirit:portMap>
               <spirit:logicalPort>
                  <spirit:name>paddr</spirit:name>
               </spirit:logicalPort>
               <spirit:physicalPort>
                  <spirit:name>paddr</spirit:name>
               </spirit:physicalPort>
            </spirit:portMap>
            <spirit:portMap>
               <spirit:logicalPort>
                  <spirit:name>pready</spirit:name>
               </spirit:logicalPort>
               <spirit:physicalPort>
                  <spirit:name>pready</spirit:name>
               </spirit:physicalPort>
            </spirit:portMap>
            <spirit:portMap>
               <spirit:logicalPort>
                  <spirit:name>prdata</spirit:name>
               </spirit:logicalPort>
               <spirit:physicalPort>
                  <spirit:name>prdata</spirit:name>
               </spirit:physicalPort>
            </spirit:portMap>
            <spirit:portMap>
               <spirit:logicalPort>
                  <spirit:name>pslverr</spirit:name>
               </spirit:logicalPort>
               <spirit:physicalPort>
                  <spirit:name>pslverr</spirit:name>
               </spirit:physicalPort>
            </spirit:portMap>
         </spirit:portMaps>
      </spirit:busInterface>
   </spirit:busInterfaces>
   <spirit:memoryMaps>  <!-- //
                    chip : bb_chip  --> 
<spirit:memoryMap>
         <spirit:name>bb_chip</spirit:name>
         <spirit:description>BlackBird Registers for A7 Core
</spirit:description>        
         <spirit:addressBlock>     
            <spirit:name>leon2</spirit:name>
            <spirit:description>LEON2 Registers
</spirit:description>  <!-- //
                        block : leon2  --> 
            <spirit:baseAddress>0x80000000</spirit:baseAddress>               
            <spirit:range>0x100</spirit:range>               
            <spirit:width>32</spirit:width>
  <!-- reg group
                    :mem_ctrl  --> 
          <spirit:registerFile>
               <spirit:name>mem_ctrl</spirit:name>
               <spirit:description>Memory controller</spirit:description>
               <spirit:addressOffset>0x0</spirit:addressOffset>
               <spirit:range>0xC</spirit:range>            
               <spirit:register>
                  <spirit:name>mcfg1</spirit:name>
                  <spirit:description>Memory configuration register 1</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000311</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>io_bus_width</spirit:name>
                     <spirit:description>I/O bus width. Defines the data width of the I/O area.
2'b00 : 8
2'b01 : 16
2'b10 : 32
2'b11 : Reserved</spirit:description>
                     <spirit:bitOffset>27</spirit:bitOffset>
                     <spirit:bitWidth>2</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>bus_rdy_en</spirit:name>
                     <spirit:description>Bus ready (BRDYN) enable.</spirit:description>
                     <spirit:bitOffset>26</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>bus_err_en</spirit:name>
                     <spirit:description>Bus error (BEXCN) enable.</spirit:description>
                     <spirit:bitOffset>25</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>io_ws</spirit:name>
                     <spirit:description>I/O wait states. Defines the number of wait states during I/O accesses.
4'b0000 : 0
4'b0001 : 1
.
4'b1111: 15</spirit:description>
                     <spirit:bitOffset>20</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>io_en</spirit:name>
                     <spirit:description>I/O enable. If set, access to the memory bus I/O area is enabled.</spirit:description>
                     <spirit:bitOffset>19</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>prom_wr_en</spirit:name>
                     <spirit:description>PROM write enable. If set, enables write cycles to the PROM area.</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>prom_width</spirit:name>
                     <spirit:description>PROM width. Defines the data width of the PROM area.
2'b00 : 8
2'b01 : 16
2'b10 : 32
2'b11 : Reserved</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>2</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>11</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>prom_wr_ws</spirit:name>
                     <spirit:description>PROM write wait states. Defines the number of wait states during PROM write cycles.
4'b0000 : 0
4'b0001 : 1
.
4'b1111: 15</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0001</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>prom_rd_ws</spirit:name>
                     <spirit:description>PROM read wait states. Defines the number of wait states during PROM read cycles.
4'b0000 : 0
4'b0001 : 1
.
4'b1111: 15</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0001</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000000</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>mcfg2</spirit:name>
                  <spirit:description>Memory configuration register 2</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x7C400000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>sdram_refresh</spirit:name>
                     <spirit:description>SDRAM refresh. If set, the SDRAM refresh will be enabled.</spirit:description>
                     <spirit:bitOffset>31</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sdram_trp</spirit:name>
                     <spirit:description>SDRAM tRP timing. tRP will be equal to 2 or 3 system clocks (0/1).</spirit:description>
                     <spirit:bitOffset>30</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sdram_trfc</spirit:name>
                     <spirit:description>SDRAM tRFC timing. tRFC will be equal to 3 + field-value system clocks.</spirit:description>
                     <spirit:bitOffset>27</spirit:bitOffset>
                     <spirit:bitWidth>3</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>111</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sdram_cas_dly</spirit:name>
                     <spirit:description>SDRAM CAS delay. Selects 2 or 3 cycle CAS delay (0/1). When changed, a LOAD-COMMAND-REGISTER command must be issued at the same time. Also sets RAS/CAS delay (tRCD).</spirit:description>
                     <spirit:bitOffset>26</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sdram_bank_size</spirit:name>
                     <spirit:description>SDRAM banks size. Defines the banks size for SDRAM chip selects.
3'b000 : 4 Mbyte
3'b001 : 8 Mbyte
.
3'b111 : 512 Mbyte</spirit:description>
                     <spirit:bitOffset>23</spirit:bitOffset>
                     <spirit:bitWidth>3</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sdram_col_size</spirit:name>
                     <spirit:description>SDRAM column size.
2'b00 : 256
2'b01 : 512
2'b10 : 1024
2'b11 : 2048 - when [25:23] != 3'b111
2'b11 : 4096 - when [25:23] == 3'b111</spirit:description>
                     <spirit:bitOffset>21</spirit:bitOffset>
                     <spirit:bitWidth>2</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>10</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sdram_cmd</spirit:name>
                     <spirit:description>SDRAM command. Writing non-zero value will generate an SDRAM command. The field is reset after command has been executed.
2'b00 : Reserved
2'b01 : PRECHARGE
2'b10 : AUTO-REFRESH
2'b11 : LOAD-COMMAND-REGISTER</spirit:description>
                     <spirit:bitOffset>19</spirit:bitOffset>
                     <spirit:bitWidth>2</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sdram_64</spirit:name>
                     <spirit:description>64-bit SDRAM. If set, the SDRAM controller is configured to use 64-bit wide SDRAM.</spirit:description>
                     <spirit:bitOffset>18</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sdram_enable</spirit:name>
                     <spirit:description>SDRAM enable. If set, the SDRAM controller will be enabled.</spirit:description>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sram_disable</spirit:name>
                     <spirit:description>SRAM disable. If set together with bit 14 (SDRAM enable), the static RAM access will be disabled.</spirit:description>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ram_bank_size</spirit:name>
                     <spirit:description>RAM bank size. Defines the size of each RAM bank.
4'b0000 : 8 Kbyte
4'b0001 : 16 Kbyte
.
4'b1111 : 256 Mbyte</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>bus_rdy_en</spirit:name>
                     <spirit:description>Bus ready enable. If set, will enable BRDYN for RAM area.</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rmw</spirit:name>
                     <spirit:description>Read-Modify-Write. Enable read-modify-write cycles on sub-word writes to 16- and 32-bit areas with common write strobe (no byte write strobe).</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ram_width</spirit:name>
                     <spirit:description>RAM width. Defines the data width of the RAM area.
2'b00 : 8
2'b01 : 16
2'b10 : 32
2'b11 : Reserved</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>2</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ram_wr_ws</spirit:name>
                     <spirit:description>RAM write wait states. Defines the number of wait statesduring RAM write cycles.
2'b00 : 0
2'b01 : 1
2'b10 : 2
2'b11 : 3</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>2</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ram_rd_ws</spirit:name>
                     <spirit:description>RAM read wait states. Defines the number of wait states during RAM read cycles.
2'b00 : 0
2'b01 : 1
2'b10 : 2
2'b11 : 3</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>2</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000004</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>mcfg3</spirit:name>
                  <spirit:description>Memory configuration register 3</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>sdram_refresh_val</spirit:name>
                     <spirit:description>Reload value for the SDRAM refresh counter.</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>15</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000008</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000000</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : mem_ctrl  --> 

  <!-- reg group
                    :ahb_stat  --> 
          <spirit:registerFile>
               <spirit:name>ahb_stat</spirit:name>
               <spirit:description>AHB Status</spirit:description>
               <spirit:addressOffset>0xC</spirit:addressOffset>
               <spirit:range>0x8</spirit:range>            
               <spirit:register>
                  <spirit:name>ahb_failing</spirit:name>
                  <spirit:description>AHB failing address</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>ahb_failing</spirit:name>
                     <spirit:description>AHB failing register. The address of the transaction that caused an AHB error response.</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>32</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000000000000000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000000C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>ahb_status</spirit:name>
                  <spirit:description>AHB status register</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>error</spirit:name>
                     <spirit:description>Error. This bit is set when an error occurred. Write a 1 to clear this field.</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rw</spirit:name>
                     <spirit:description>RW - Read/Write. This bit is set if the failed access was a read cycle, otherwise it is cleared.</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hmaster</spirit:name>
                     <spirit:description>HMASTER - AHB master. This field contains the HMASTER[3:0] of the failed access.</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hsize</spirit:name>
                     <spirit:description>HSIZE - transfer size. This field contains the HSIZE[2:0] of the failed transfer.</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>3</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000010</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x8000000C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : ahb_stat  --> 

  <!-- reg group
                    :cache_controller  --> 
          <spirit:registerFile>
               <spirit:name>cache_controller</spirit:name>
               <spirit:description>Cache Controller</spirit:description>
               <spirit:addressOffset>0x14</spirit:addressOffset>
               <spirit:range>0x8</spirit:range>            
               <spirit:register>
                  <spirit:name>cache_control</spirit:name>
                  <spirit:description>Cache control register (CRR)</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>drepl</spirit:name>
                     <spirit:description>Data cache replacement policy (DREPL):
2'b00 : no replacement policy (direct-mapped cache)
2'b01 : random
2'b10 : least-recently-replaced (LRR)
2'b11 : least-recenty-used (LRU)</spirit:description>
                     <spirit:bitOffset>30</spirit:bitOffset>
                     <spirit:bitWidth>2</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>irepl</spirit:name>
                     <spirit:description>Instruction cache replacement policy (IREPL):
2'b00 : no replacement policy (direct-mapped cache)
2'b01 : random
2'b10 : least-recently-replaced (LRR)
2'b11 : least-recenty-used (LRU)</spirit:description>
                     <spirit:bitOffset>28</spirit:bitOffset>
                     <spirit:bitWidth>2</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>isets</spirit:name>
                     <spirit:description>Instruction cache associativity (ISETS) - Number of sets in the instruction cache:
2'b00 : direct mapped
2'b01 : 2-way associative
2'b10 : 3-way associative
2'b11 : 4-way associative</spirit:description>
                     <spirit:bitOffset>26</spirit:bitOffset>
                     <spirit:bitWidth>2</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dsets</spirit:name>
                     <spirit:description>Data cache associativity (DSETS) - Number of sets in the data cache:
2'b00 : direct mapped
2'b01 : 2-way associative
2'b10 : 3-way associative
2'b11 : 4-way associative</spirit:description>
                     <spirit:bitOffset>24</spirit:bitOffset>
                     <spirit:bitWidth>2</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ds</spirit:name>
                     <spirit:description>Data cache snoop enable (DS) - If set, will enable data cache snooping.</spirit:description>
                     <spirit:bitOffset>23</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fd</spirit:name>
                     <spirit:description>Flush Data cache (FD) - If set, will flush the data cache. Always reads as zero.</spirit:description>
                     <spirit:bitOffset>22</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>write-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fi</spirit:name>
                     <spirit:description>Flush Instruction cache (FI) - If set, will flush the instruction cache. Always reads as zero.</spirit:description>
                     <spirit:bitOffset>21</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>write-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ib</spirit:name>
                     <spirit:description>Instruction burst fetch (IB) - This bit enables burst fill during instruction fetch.</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ip</spirit:name>
                     <spirit:description>Instruction cache flush pending (IP) - This bit is set when an instruction cache flush operation is in progress.</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp</spirit:name>
                     <spirit:description>Data cache flush pending (DP) - This bit is set when a data cache flush operation is in progress.</spirit:description>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dcf</spirit:name>
                     <spirit:description>Data Cache Freeze on Interrupt (DCF) - If set, the data cache will automatically be frozen when an asynchronous interrupt is taken.</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>icf</spirit:name>
                     <spirit:description>Instruction Cache Freeze on Interrupt (ICF) - If set, the instruction cache will automatically be frozen when an asynchronous interrupt is taken.</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dcs</spirit:name>
                     <spirit:description>Data Cache State (DCS) - Indicates the current data cache state according to the following:
2'b00 : Disabled
2'b01 : Frozen
2'b10 : Disabled
2'b11 : Enabled</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>2</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ics</spirit:name>
                     <spirit:description>Instruction Cache State (ICS) - Indicates the current instruction cache state according to the following:
2'b00 : Disabled
2'b01 : Frozen
2'b10 : Disabled
2'b11 : Enabled</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>2</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000014</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>power_down</spirit:name>
                  <spirit:description>Power down register</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>pd</spirit:name>
                     <spirit:description>The processor can be powered-down by writing an arbitrary value to the power-down register. Power-down mode will be entered on the next load or store instruction. To enter power-down mode immediately, a store to the power-down register should be performed followed by a dummy load.</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>32</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>write-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000000000000000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000018</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000014</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : cache_controller  --> 

  <!-- reg group
                    :write_prot  --> 
          <spirit:registerFile>
               <spirit:name>write_prot</spirit:name>
               <spirit:description>Write Protection</spirit:description>
               <spirit:addressOffset>0x1C</spirit:addressOffset>
               <spirit:range>0x8</spirit:range>            
               <spirit:register>
                  <spirit:name>write_prot1</spirit:name>
                  <spirit:description>Write protection register 1</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>en</spirit:name>
                     <spirit:description>Enable (EN) - If set, enables the write protect unit</spirit:description>
                     <spirit:bitOffset>31</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>bp</spirit:name>
                     <spirit:description>Block Protect (BP) - If set, selects block protect mode</spirit:description>
                     <spirit:bitOffset>30</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tag</spirit:name>
                     <spirit:description>Address tag (TAG) - This field is compared against address (29:15)</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>15</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mask</spirit:name>
                     <spirit:description>Address mask (MASK) - This field contains the address mask</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>15</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000001C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>write_prot2</spirit:name>
                  <spirit:description>Write protection register 2</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>en</spirit:name>
                     <spirit:description>Enable (EN) - If set, enables the write protect unit</spirit:description>
                     <spirit:bitOffset>31</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>bp</spirit:name>
                     <spirit:description>Block Protect (BP) - If set, selects block protect mode</spirit:description>
                     <spirit:bitOffset>30</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tag</spirit:name>
                     <spirit:description>Address tag (TAG) - This field is compared against address (29:15)</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>15</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mask</spirit:name>
                     <spirit:description>Address mask (MASK) - This field contains the address mask</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>15</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000020</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x8000001C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : write_prot  --> 
            <spirit:register>
               <spirit:name>leon_config</spirit:name>
               <spirit:description>LEON configuration register</spirit:description>
               <spirit:addressOffset>0x24</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>dsu</spirit:name>
                  <spirit:description>Debug support unit present
1'b0 : disabled
1'b1 : present</spirit:description>
                  <spirit:bitOffset>30</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>sdram_ctrl</spirit:name>
                  <spirit:description>SDRAM controller present
1'b0 : disabled
1'b1 : present</spirit:description>
                  <spirit:bitOffset>29</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>num_wp</spirit:name>
                  <spirit:description>Number of implemented watchpoints (0 - 4)</spirit:description>
                  <spirit:bitOffset>26</spirit:bitOffset>
                  <spirit:bitWidth>3</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>mac</spirit:name>
                  <spirit:description>UMAC/SMAC instruction implemented</spirit:description>
                  <spirit:bitOffset>25</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>nwindows</spirit:name>
                  <spirit:description>Number of register windows. The implemented number of SPARC register windows - 1.</spirit:description>
                  <spirit:bitOffset>20</spirit:bitOffset>
                  <spirit:bitWidth>5</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>icsz</spirit:name>
                  <spirit:description>Instruction cache size. The size (in Kbytes) of the instruction cache. Cache size = 2^icsz.</spirit:description>
                  <spirit:bitOffset>17</spirit:bitOffset>
                  <spirit:bitWidth>3</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>ilsz</spirit:name>
                  <spirit:description>Instruction cache line size. The line size (in 32-bit words) of each line. Line size = 2^ilsz.</spirit:description>
                  <spirit:bitOffset>15</spirit:bitOffset>
                  <spirit:bitWidth>2</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>dcsz</spirit:name>
                  <spirit:description>Data cache size. The size (in Kbytes) of the data cache. Cache size = 2^dcsz.</spirit:description>
                  <spirit:bitOffset>12</spirit:bitOffset>
                  <spirit:bitWidth>3</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>dlsz</spirit:name>
                  <spirit:description>Data cache line size. The line size (in 32-bit words) of each line. Line size = 2^dlsz.</spirit:description>
                  <spirit:bitOffset>10</spirit:bitOffset>
                  <spirit:bitWidth>2</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>div</spirit:name>
                  <spirit:description>UDIV/SDIV instruction implemented</spirit:description>
                  <spirit:bitOffset>9</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>mul</spirit:name>
                  <spirit:description>UMUL/SMUL instruction implemented</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>ahb_stat</spirit:name>
                  <spirit:description>Memory status and failing address register present</spirit:description>
                  <spirit:bitOffset>6</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fpu</spirit:name>
                  <spirit:description>FPU type
2'b00 : none
2'b01 : Meiko</spirit:description>
                  <spirit:bitOffset>4</spirit:bitOffset>
                  <spirit:bitWidth>2</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>pci_core</spirit:name>
                  <spirit:description>PCI core type
2'b00 : none
2'b01 : InSilicon
2'b10 : ESA
2'b11 : Other</spirit:description>
                  <spirit:bitOffset>2</spirit:bitOffset>
                  <spirit:bitWidth>2</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>write_prot</spirit:name>
                  <spirit:description>Write protection type
2'b00 : none
2'b01 : standard</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>2</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000024</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>
  <!-- reg group
                    :timers  --> 
          <spirit:registerFile>
               <spirit:name>timers</spirit:name>
               <spirit:description>Timers</spirit:description>
               <spirit:addressOffset>0x40</spirit:addressOffset>
               <spirit:range>0x28</spirit:range>            
               <spirit:register>
                  <spirit:name>timer1_counter</spirit:name>
                  <spirit:description>Timer 1 counter register</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>counter</spirit:name>
                     <spirit:description>Timer 1 counter value</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>24</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000000000000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000040</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>timer1_reload</spirit:name>
                  <spirit:description>Timer 1 reload register</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>reload</spirit:name>
                     <spirit:description>Timer 1 reload value</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>24</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000000000000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000044</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>timer1_control</spirit:name>
                  <spirit:description>Timer 1 control register</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>ld</spirit:name>
                     <spirit:description>Load counter (LD) - When written with 1, will load the timer reload register into the timer counter register. Always reads as a 0.</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rl</spirit:name>
                     <spirit:description>Reload counter (RL) - If RL is set, then the counter will automatically be reloaded with the reload value after each underflow.</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>en</spirit:name>
                     <spirit:description>Enable (EN) - Enables the timer when set.</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000048</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>watchdog_counter</spirit:name>
                  <spirit:description>Watchdog counter register</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>counter</spirit:name>
                     <spirit:description>Watchdog counter value</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>24</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000000000000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000004C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>timer2_counter</spirit:name>
                  <spirit:description>Timer 2 counter register</spirit:description>
                  <spirit:addressOffset>0x10</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>counter</spirit:name>
                     <spirit:description>Timer 2 counter value</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>24</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000000000000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000050</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>timer2_reload</spirit:name>
                  <spirit:description>Timer 2 reload register</spirit:description>
                  <spirit:addressOffset>0x14</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>reload</spirit:name>
                     <spirit:description>Timer 2 reload value</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>24</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000000000000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000054</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>timer2_control</spirit:name>
                  <spirit:description>Timer 2 control register</spirit:description>
                  <spirit:addressOffset>0x18</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>ld</spirit:name>
                     <spirit:description>Load counter (LD) - When written with 1, will load the timer reload register into the timer counter register. Always reads as a 0.</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rl</spirit:name>
                     <spirit:description>Reload counter (RL) - If RL is set, then the counter will automatically be reloaded with the reload value after each underflow.</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>en</spirit:name>
                     <spirit:description>Enable (EN) - Enables the timer when set.</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000058</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>prescaler_counter</spirit:name>
                  <spirit:description>Prescaler counter register</spirit:description>
                  <spirit:addressOffset>0x20</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>counter</spirit:name>
                     <spirit:description>Prescaler counter value</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>10</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000060</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>prescaler_reload</spirit:name>
                  <spirit:description>Prescaler reload register</spirit:description>
                  <spirit:addressOffset>0x24</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>reload</spirit:name>
                     <spirit:description>Prescaler reload value</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>10</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000064</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000040</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : timers  --> 

  <!-- reg group
                    :uarts  --> 
          <spirit:registerFile>
               <spirit:name>uarts</spirit:name>
               <spirit:description>UARTS</spirit:description>
               <spirit:addressOffset>0x70</spirit:addressOffset>
               <spirit:range>0x20</spirit:range>            
               <spirit:register>
                  <spirit:name>uart1_data</spirit:name>
                  <spirit:description>UART1 data register</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>data</spirit:name>
                     <spirit:description>Holding register for both read and write access</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000070</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>uart1_status</spirit:name>
                  <spirit:description>UART1 status register</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>fe</spirit:name>
                     <spirit:description>Framing error (FE) - Indicates that a framing error was detected.</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>pe</spirit:name>
                     <spirit:description>Parity error (PE) - Indicates that a parity error was detected.</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ov</spirit:name>
                     <spirit:description>Overrun (OV) - Indicates that one or more characters have been lost due to overrun.</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>br</spirit:name>
                     <spirit:description>Break received (BR) - Indicates that a BREAK has been received.</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>th</spirit:name>
                     <spirit:description>Transmitter hold register empty (TH) - Indicates that the transmitter hold register is empty.</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ts</spirit:name>
                     <spirit:description>Transmitter shift register empty (TS) - Indicates that the transmitter shift register is empty.</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dr</spirit:name>
                     <spirit:description>Data ready (DR) - Indicates that new data is available in the receiver holding register.</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000074</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>uart1_control</spirit:name>
                  <spirit:description>UART1 control register</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>ec</spirit:name>
                     <spirit:description>External clock (EC) - If set, the UART scaler will be clocked by PIO[3].</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lb</spirit:name>
                     <spirit:description>Loop back (LB) - If set, loop back mode will be enabled.</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fl</spirit:name>
                     <spirit:description>Flow control (FL) - If set, enables flow control using CTS/RTS.</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>pe</spirit:name>
                     <spirit:description>Parity enable (PE) - If set, enables parity generation and checking.</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ps</spirit:name>
                     <spirit:description>Parity select (PS) - Selects parity polarity.
1'b0 : even parity
1'b1 : odd parity</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ti</spirit:name>
                     <spirit:description>Transmitter interrupt enable (RI) - If set, enables generation of transmitter interrupt.</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ri</spirit:name>
                     <spirit:description>Receiver interrupt enable (RI) - If set, enables generation of receiver interrupt.</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>te</spirit:name>
                     <spirit:description>Transmitter enable (TE) - If set, enables the transmitter.</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>re</spirit:name>
                     <spirit:description>Receiver enable (RE) - If set, enables the receiver.</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000078</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>uart1_scaler</spirit:name>
                  <spirit:description>UART1 scaler register</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>scaler</spirit:name>
                     <spirit:description>UART1 scaler reload value</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>12</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000007C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>uart2_data</spirit:name>
                  <spirit:description>UART2 data register</spirit:description>
                  <spirit:addressOffset>0x10</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>data</spirit:name>
                     <spirit:description>Holding register for both read and write access</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000080</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>uart2_status</spirit:name>
                  <spirit:description>UART2 status register</spirit:description>
                  <spirit:addressOffset>0x14</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>fe</spirit:name>
                     <spirit:description>Framing error (FE) - Indicates that a framing error was detected.</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>pe</spirit:name>
                     <spirit:description>Parity error (PE) - Indicates that a parity error was detected.</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ov</spirit:name>
                     <spirit:description>Overrun (OV) - Indicates that one or more characters have been lost due to overrun.</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>br</spirit:name>
                     <spirit:description>Break received (BR) - Indicates that a BREAK has been received.</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>th</spirit:name>
                     <spirit:description>Transmitter hold register empty (TH) - Indicates that the transmitter hold register is empty.</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ts</spirit:name>
                     <spirit:description>Transmitter shift register empty (TS) - Indicates that the transmitter shift register is empty.</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dr</spirit:name>
                     <spirit:description>Data ready (DR) - Indicates that new data is available in the receiver holding register.</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000084</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>uart2_control</spirit:name>
                  <spirit:description>UART2 control register</spirit:description>
                  <spirit:addressOffset>0x18</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>ec</spirit:name>
                     <spirit:description>External clock (EC) - If set, the UART scaler will be clocked by PIO[3].</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lb</spirit:name>
                     <spirit:description>Loop back (LB) - If set, loop back mode will be enabled.</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fl</spirit:name>
                     <spirit:description>Flow control (FL) - If set, enables flow control using CTS/RTS.</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>pe</spirit:name>
                     <spirit:description>Parity enable (PE) - If set, enables parity generation and checking.</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ps</spirit:name>
                     <spirit:description>Parity select (PS) - Selects parity polarity.
1'b0 : even parity
1'b1 : odd parity</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ti</spirit:name>
                     <spirit:description>Transmitter interrupt enable (RI) - If set, enables generation of transmitter interrupt.</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ri</spirit:name>
                     <spirit:description>Receiver interrupt enable (RI) - If set, enables generation of receiver interrupt.</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>te</spirit:name>
                     <spirit:description>Transmitter enable (TE) - If set, enables the transmitter.</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>re</spirit:name>
                     <spirit:description>Receiver enable (RE) - If set, enables the receiver.</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000088</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>uart2_scaler</spirit:name>
                  <spirit:description>UART2 scaler register</spirit:description>
                  <spirit:addressOffset>0x1C</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>scaler</spirit:name>
                     <spirit:description>UART2 scaler reload value</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>12</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000008C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000070</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : uarts  --> 

  <!-- reg group
                    :irqctrl  --> 
          <spirit:registerFile>
               <spirit:name>irqctrl</spirit:name>
               <spirit:description>Interrupt controller</spirit:description>
               <spirit:addressOffset>0x90</spirit:addressOffset>
               <spirit:range>0x10</spirit:range>            
               <spirit:register>
                  <spirit:name>int_mask</spirit:name>
                  <spirit:description>Interrupt mask register</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>ilevel</spirit:name>
                     <spirit:description>Interrupt level (ILEVEL[15:1]) - Indicates whether an interrupt belongs to priority level 1 (ILEVEL[n]=1 or level 0 (ILEVEL[n]=0).</spirit:description>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>15</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>imask</spirit:name>
                     <spirit:description>Interrupt mask (IMASK[15:1]) - Indicates whether an interrupt is masked (IMASK[n]=0 or enabled (IMASK[n]=1).</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>15</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000090</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>int_pending</spirit:name>
                  <spirit:description>Interrupt pending register</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>ipend</spirit:name>
                     <spirit:description>Interrupt pending (IPEND[15:1]) - Indicates whether an interrupt is pending (IPEND[n]=1).</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>15</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000094</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>int_force</spirit:name>
                  <spirit:description>Interrupt force register</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>iforce</spirit:name>
                     <spirit:description>Interrupt force (IFORCE[15:1]) - Indicates whether an interrupt is being forced (IFORCE[n]=1).</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>15</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000098</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>int_clear</spirit:name>
                  <spirit:description>Interrupt clear register</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>iclear</spirit:name>
                     <spirit:description>Interrupt clear (ICLEAR[15:1]) - If written with a 1, will clear the corresponding bit(s) in the interrupt pending register. A read returns 0.</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>15</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000009C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000090</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : irqctrl  --> 

  <!-- reg group
                    :io_port  --> 
          <spirit:registerFile>
               <spirit:name>io_port</spirit:name>
               <spirit:description>I/O Port</spirit:description>
               <spirit:addressOffset>0xA0</spirit:addressOffset>
               <spirit:range>0xC</spirit:range>            
               <spirit:register>
                  <spirit:name>io_val</spirit:name>
                  <spirit:description>I/O port input/output register</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>ioval</spirit:name>
                     <spirit:description>IOVALn - I/O port value. On a read the I/O ports that are configured as inputs return their current value. When written, the value will be driven onto the I/O ports that are configured as outputs.</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800000A0</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>io_dir</spirit:name>
                  <spirit:description>I/O port direction register</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>iodir</spirit:name>
                     <spirit:description>IODIRn - I/O port direction. The value of IODIR[15:0] defines the direction of I/O ports 15 - 0 (PIO[15:0]). If bit n is set the corresponding I/O port becomes an output, otherwise it is an input. IODIR[16] controls D[15:8] while IODIR[17] controls D[7:0].</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>18</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800000A4</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>io_int_cfg</spirit:name>
                  <spirit:description>I/O port interrupt config register</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>en3</spirit:name>
                     <spirit:description>EN3 - Enable. If set, the corresponding interrupt will be enabled, otherwise it will be masked.</spirit:description>
                     <spirit:bitOffset>31</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>le3</spirit:name>
                     <spirit:description>LE3 - Level/edge triggered. If set, the interrupt will be edge-triggered, otherwise level sensitive.</spirit:description>
                     <spirit:bitOffset>30</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>pl3</spirit:name>
                     <spirit:description>PL3 - Polarity. If set, the corresponding interrupt will be active high (or edge-triggered on positive edge). Otherwise, it will be active low (or edge-triggered on negative edge).</spirit:description>
                     <spirit:bitOffset>29</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>isel3</spirit:name>
                     <spirit:description>ISEL3 - I/O port select. The value of this field defines which I/O port (0 - 31) should generate parallel I/O port interrupt 3.</spirit:description>
                     <spirit:bitOffset>24</spirit:bitOffset>
                     <spirit:bitWidth>5</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>en2</spirit:name>
                     <spirit:description>EN2 - Enable. If set, the corresponding interrupt will be enabled, otherwise it will be masked.</spirit:description>
                     <spirit:bitOffset>23</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>le2</spirit:name>
                     <spirit:description>LE2 - Level/edge triggered. If set, the interrupt will be edge-triggered, otherwise level sensitive.</spirit:description>
                     <spirit:bitOffset>22</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>pl2</spirit:name>
                     <spirit:description>PL2 - Polarity. If set, the corresponding interrupt will be active high (or edge-triggered on positive edge). Otherwise, it will be active low (or edge-triggered on negative edge).</spirit:description>
                     <spirit:bitOffset>21</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>isel2</spirit:name>
                     <spirit:description>ISEL2 - I/O port select. The value of this field defines which I/O port (0 - 31) should generate parallel I/O port interrupt 2.</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>5</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>en1</spirit:name>
                     <spirit:description>EN1 - Enable. If set, the corresponding interrupt will be enabled, otherwise it will be masked.</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>le1</spirit:name>
                     <spirit:description>LE1 - Level/edge triggered. If set, the interrupt will be edge-triggered, otherwise level sensitive.</spirit:description>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>pl1</spirit:name>
                     <spirit:description>PL1 - Polarity. If set, the corresponding interrupt will be active high (or edge-triggered on positive edge). Otherwise, it will be active low (or edge-triggered on negative edge).</spirit:description>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>isel1</spirit:name>
                     <spirit:description>ISEL1 - I/O port select. The value of this field defines which I/O port (0 - 31) should generate parallel I/O port interrupt 1.</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>5</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>en0</spirit:name>
                     <spirit:description>EN0 - Enable. If set, the corresponding interrupt will be enabled, otherwise it will be masked.</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>le0</spirit:name>
                     <spirit:description>LE0 - Level/edge triggered. If set, the interrupt will be edge-triggered, otherwise level sensitive.</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>pl0</spirit:name>
                     <spirit:description>PL0 - Polarity. If set, the corresponding interrupt will be active high (or edge-triggered on positive edge). Otherwise, it will be active low (or edge-triggered on negative edge).</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>isel0</spirit:name>
                     <spirit:description>ISEL0 - I/O port select. The value of this field defines which I/O port (0 - 31) should generate parallel I/O port interrupt 0.</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>5</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800000A8</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x800000A0</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : io_port  --> 

  <!-- reg group
                    :irqctrl2  --> 
          <spirit:registerFile>
               <spirit:name>irqctrl2</spirit:name>
               <spirit:description>Secondary interrupt controller</spirit:description>
               <spirit:addressOffset>0xB0</spirit:addressOffset>
               <spirit:range>0xC</spirit:range>            
               <spirit:register>
                  <spirit:name>int_mask</spirit:name>
                  <spirit:description>Secondary interrupt mask register</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>imask</spirit:name>
                     <spirit:description>Interrupt mask - Indicates whether an interrupt is masked (IMASK[n]=0 or enabled (IMASK[n]=1).</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>32</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000000000000000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800000B0</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>int_pending</spirit:name>
                  <spirit:description>Secondary interrupt pending register</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>ipend</spirit:name>
                     <spirit:description>Interrupt pending - Indicates whether an interrupt is pending (IPEND[n]=1).</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>32</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000000000000000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800000B4</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>int_status_clear</spirit:name>
                  <spirit:description>Secondary interrupt status and clear register</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>iclear</spirit:name>
                     <spirit:description>Interrupt clear - If written with a 1, will clear the corresponding bit(s) in the interrupt pending register. A read returns 0.</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>26</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000000000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ip_or_iclear</spirit:name>
                     <spirit:description>Interrupt pending - If set, then IRL is valid. If cleared, no unmasked interrupt is pending. When written, clears pending secondary interrupt 5.</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>irl_or_iclear</spirit:name>
                     <spirit:description>Interrupt request level - Indicates the highest unmasked pending interrupt. When written, clears the pending secondary interrupts (4:0) that have their bit set to 1.</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>5</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800000B8</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x800000B0</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : irqctrl2  --> 

  <!-- reg group
                    :dsu_uart  --> 
          <spirit:registerFile>
               <spirit:name>dsu_uart</spirit:name>
               <spirit:description>DSU UART</spirit:description>
               <spirit:addressOffset>0xC4</spirit:addressOffset>
               <spirit:range>0xC</spirit:range>            
               <spirit:register>
                  <spirit:name>dsu_status</spirit:name>
                  <spirit:description>DSU status register</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>fe</spirit:name>
                     <spirit:description>Framing error (FE) - Indicates that a framing error was detected.</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ov</spirit:name>
                     <spirit:description>Overrun (OV) - Indicates that one or more characters have been lost due to overrun.</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>th</spirit:name>
                     <spirit:description>Transmitter hold register empty (TH) - Indicates that the transmitter hold register is empty.</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ts</spirit:name>
                     <spirit:description>Transmitter shift register empty (TS) - Indicates that the transmitter shift register is empty.</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dr</spirit:name>
                     <spirit:description>Data ready (DR) - Indicates that new data has been received and not yet read-out by the AHB master interface.</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800000C4</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>dsu_control</spirit:name>
                  <spirit:description>DSU control register</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>bl</spirit:name>
                     <spirit:description>Baud rate locked (BL) - Is automatically set when the baud rate is locked.</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>en</spirit:name>
                     <spirit:description>Receiver enable (RE) - If set, enables both the transmitter and receiver.</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800000C8</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>dsu_scaler</spirit:name>
                  <spirit:description>DSU scaler register</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>scaler</spirit:name>
                     <spirit:description>Scaler reload value = (((system_clk_in_hz*10)/(baudrate*8))-5)/10</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>14</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800000CC</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x800000C4</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : dsu_uart  --> 
         <spirit:vendorExtensions>
               <ids_properties>
                  <module_name>leon2_regs</module_name>
                  <uvm.package>leon2_regs_pkg</uvm.package>
                  <reset_type>async</reset_type>
                  <cheader.mask_endianess>little</cheader.mask_endianess>
                  <header.struct_guard>__ASSEMBLER__</header.struct_guard>
                  <explicit_name>true</explicit_name>
                  <vertical_reuse>true</vertical_reuse>
                  <address>0x80000000</address>
               </ids_properties>
            </spirit:vendorExtensions>
         </spirit:addressBlock>     
         <spirit:addressBlock>     
            <spirit:name>uart</spirit:name>
            <spirit:description>FIFO-based UART
</spirit:description>  <!-- //
                        block : uart  --> 
            <spirit:baseAddress>0x80000500</spirit:baseAddress>               
            <spirit:range>0x100</spirit:range>               
            <spirit:width>32</spirit:width>            
            <spirit:register>
               <spirit:name>version</spirit:name>
               <spirit:description>Version</spirit:description>
               <spirit:addressOffset>0x0</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00040000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>major</spirit:name>
                  <spirit:description>Major version</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000100</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>minor</spirit:name>
                  <spirit:description>Minor version</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>patch</spirit:name>
                  <spirit:description>Patch version</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000500</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>tx_fifo</spirit:name>
               <spirit:description>TX FIFO control and status</spirit:description>
               <spirit:addressOffset>0x4</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>fifo_clear</spirit:name>
                  <spirit:description>FIFO clear
</spirit:description>
                  <spirit:bitOffset>31</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                     <ids_properties>
                        <rtl.hw_wp>1</rtl.hw_wp>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_af</spirit:name>
                  <spirit:description>FIFO almost full status field. A 1 indicates an almost full or full FIFO. This bit is set when there are between fifo_aft and fifo_depth number of entries in the FIFO.</spirit:description>
                  <spirit:bitOffset>27</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_ae</spirit:name>
                  <spirit:description>FIFO almost empty status field. A 1 indicates an almost empty or empty FIFO. This bit is set when there are between 0 and fifo_aet number of entries in the FIFO.</spirit:description>
                  <spirit:bitOffset>26</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_full</spirit:name>
                  <spirit:description>FIFO full status field. A 1 indicates a full FIFO.</spirit:description>
                  <spirit:bitOffset>25</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_empty</spirit:name>
                  <spirit:description>FIFO empty status field. A 1 indicates an empty FIFO.</spirit:description>
                  <spirit:bitOffset>24</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_aft</spirit:name>
                  <spirit:description>FIFO almost full threshold</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_aet</spirit:name>
                  <spirit:description>FIFO almost empty threshold</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_depth</spirit:name>
                  <spirit:description>FIFO depth (always 1 byte wide)</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000504</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>rx_fifo</spirit:name>
               <spirit:description>RX FIFO control and status</spirit:description>
               <spirit:addressOffset>0x8</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>fifo_clear</spirit:name>
                  <spirit:description>FIFO clear
</spirit:description>
                  <spirit:bitOffset>31</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                     <ids_properties>
                        <rtl.hw_wp>1</rtl.hw_wp>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_af</spirit:name>
                  <spirit:description>FIFO almost full status field. A 1 indicates an almost full or full FIFO. This bit is set when there are between fifo_aft and fifo_depth number of entries in the FIFO.</spirit:description>
                  <spirit:bitOffset>27</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_ae</spirit:name>
                  <spirit:description>FIFO almost empty status field. A 1 indicates an almost empty or empty FIFO. This bit is set when there are between 0 and fifo_aet number of entries in the FIFO.</spirit:description>
                  <spirit:bitOffset>26</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_full</spirit:name>
                  <spirit:description>FIFO full status field. A 1 indicates a full FIFO.</spirit:description>
                  <spirit:bitOffset>25</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_empty</spirit:name>
                  <spirit:description>FIFO empty status field. A 1 indicates an empty FIFO.</spirit:description>
                  <spirit:bitOffset>24</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_aft</spirit:name>
                  <spirit:description>FIFO almost full threshold</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_aet</spirit:name>
                  <spirit:description>FIFO almost empty threshold</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_depth</spirit:name>
                  <spirit:description>FIFO depth (always 1 byte wide)</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000508</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>tx_data</spirit:name>
               <spirit:description>TX data</spirit:description>
               <spirit:addressOffset>0xC</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>val</spirit:name>
                  <spirit:description>Byte to write into the TX FIFO
</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>write-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                     <ids_properties>
                        <rtl.hw_wp>1</rtl.hw_wp>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x8000050C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>rx_data</spirit:name>
               <spirit:description>RX data</spirit:description>
               <spirit:addressOffset>0x10</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>val</spirit:name>
                  <spirit:description>Byte to read from the RX FIFO
</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                     <ids_properties>
                        <rtl.hw_rp>1</rtl.hw_rp>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000510</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>control</spirit:name>
               <spirit:description>Control</spirit:description>
               <spirit:addressOffset>0x14</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>prescaler</spirit:name>
                  <spirit:description>Prescaler reload value
round(module clock frequency / baud rate)</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>16</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0000000000000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>tx_irq_en</spirit:name>
                  <spirit:description>Transmitter interrupt enable</spirit:description>
                  <spirit:bitOffset>3</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>rx_irq_en</spirit:name>
                  <spirit:description>Receiver interrupt enable</spirit:description>
                  <spirit:bitOffset>2</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>tx_en</spirit:name>
                  <spirit:description>Transmitter enable</spirit:description>
                  <spirit:bitOffset>1</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>rx_en</spirit:name>
                  <spirit:description>Receiver enable</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000514</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>timeout</spirit:name>
               <spirit:description>Timeout</spirit:description>
               <spirit:addressOffset>0x18</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>val</spirit:name>
                  <spirit:description>&gt; 0: If no character was received within this number of module clock cycles and RX FIFO is not empty RX IRQ will be asserted. If a new character is received before timer expiry or when the timer is expired, the timer is reset and restarted.
0: Disables the timeout functionality</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>32</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000000000000000000000000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000518</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>errors</spirit:name>
               <spirit:description>Errors - Write 1 to clear</spirit:description>
               <spirit:addressOffset>0x1C</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>overrun_err</spirit:name>
                  <spirit:description>Overrun Error:
If this is 1 the RX FIFO was full and a received character had to be discarded</spirit:description>
                  <spirit:bitOffset>2</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>stop_err</spirit:name>
                  <spirit:description>Stop Error:
If this is 1 a character was received but a 0 was seen in the middle of what was expected to be the stop bit; this condition does not impact how the received character is treated</spirit:description>
                  <spirit:bitOffset>1</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>start_err</spirit:name>
                  <spirit:description>Start Error:
A falling edge on the UART RX line was detected but before reaching the middle of the start bit a 1 was seen; this condition does not impact how the received character is treated</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x8000051C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>         
            <spirit:vendorExtensions>
               <ids_properties>
                  <module_name>uart_regs</module_name>
                  <uvm.package>uart_regs_pkg</uvm.package>
                  <reset_type>async</reset_type>
                  <cheader.mask_endianess>little</cheader.mask_endianess>
                  <header.struct_guard>__ASSEMBLER__</header.struct_guard>
                  <explicit_name>true</explicit_name>
                  <vertical_reuse>true</vertical_reuse>
                  <address>0x80000500</address>
               </ids_properties>
            </spirit:vendorExtensions>
         </spirit:addressBlock>     
         <spirit:addressBlock>     
            <spirit:name>i2c_master</spirit:name>
            <spirit:description>I2C Master
</spirit:description>  <!-- //
                        block : i2c_master  --> 
            <spirit:baseAddress>0x80000600</spirit:baseAddress>               
            <spirit:range>0x100</spirit:range>               
            <spirit:width>32</spirit:width>            
            <spirit:register>
               <spirit:name>version</spirit:name>
               <spirit:description>Version</spirit:description>
               <spirit:addressOffset>0x0</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00030003</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>major</spirit:name>
                  <spirit:description>Major version</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000011</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>minor</spirit:name>
                  <spirit:description>Minor version</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>patch</spirit:name>
                  <spirit:description>Patch version</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000011</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000600</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>prescaler</spirit:name>
               <spirit:description>I2C prescaler</spirit:description>
               <spirit:addressOffset>0x4</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>prescaler</spirit:name>
                  <spirit:description>Prescaler reload value. The value defines the number of clocks in a quarter SCL period. E.g. for a 60MHz clock and a prescaler value of 15 a 1000 KHz SCL will be generated (60e6 * (1 / (15 * 4))).</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>16</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0000000000000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000604</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>fifo</spirit:name>
               <spirit:description>I2C FIFO control and status</spirit:description>
               <spirit:addressOffset>0x8</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>fifo_af</spirit:name>
                  <spirit:description>FIFO almost full status field. A 1 indicates an almost full or full FIFO. This bit is set when there are between fifo_af_lvl and fifo_depth number of entries in the FIFO.</spirit:description>
                  <spirit:bitOffset>27</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_ae</spirit:name>
                  <spirit:description>FIFO almost empty status field. A 1 indicates an almost empty or empty FIFO. This bit is set when there are between 0 and fifo_ae_lvl number of entries in the FIFO.</spirit:description>
                  <spirit:bitOffset>26</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_full</spirit:name>
                  <spirit:description>FIFO full status field. A 1 indicates a full FIFO.</spirit:description>
                  <spirit:bitOffset>25</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_empty</spirit:name>
                  <spirit:description>FIFO empty status field. A 1 indicates an empty FIFO.</spirit:description>
                  <spirit:bitOffset>24</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_aft</spirit:name>
                  <spirit:description>FIFO almost full threshold</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_aet</spirit:name>
                  <spirit:description>FIFO almost empty threshold</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_depth</spirit:name>
                  <spirit:description>FIFO depth (always 1 byte wide)</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000608</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>control</spirit:name>
               <spirit:description>I2C control</spirit:description>
               <spirit:addressOffset>0xC</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000002</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>error</spirit:name>
                  <spirit:description>Error status field. A 1 indicates that a transaction error occurred. This could be due to a NAK or a read from the bus when the FIFO is full. This bit is sticky until the clear field is asserted or a new transaction is started.</spirit:description>
                  <spirit:bitOffset>31</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>clock_stretch_active</spirit:name>
                  <spirit:description>This status field indicates whether the I2C master is currently being clock stretched (this requires clock_stretch_en to be 1)</spirit:description>
                  <spirit:bitOffset>30</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>force_sda_low</spirit:name>
                  <spirit:description>Write a 1 to force the SDA line to 0. Clear this field for normal behaviour.</spirit:description>
                  <spirit:bitOffset>25</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>slave_addr</spirit:name>
                  <spirit:description>I2C slave address</spirit:description>
                  <spirit:bitOffset>14</spirit:bitOffset>
                  <spirit:bitWidth>7</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>read_byte_count</spirit:name>
                  <spirit:description>Write the number of bytes that should be read from the I2C device before ending the transaction. The value should not be bigger than the FIFO depth.</spirit:description>
                  <spirit:bitOffset>6</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>clear</spirit:name>
                  <spirit:description>Write a 1 to clear the I2C master. This clears the FIFO and resets the state machine. The clear bit must be asserted for at least 2 PCLK cycles. HW does NOT clear this field so SW should write a 0 to this field after it has written a 1 to clear the I2C master.</spirit:description>
                  <spirit:bitOffset>5</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>opmode</spirit:name>
                  <spirit:description>Mode of Operation:
2'b00 : I2C Read
2'b01 : I2C Write / SMBus Byte Write / SMBus Block Write
2'b10 : SMBus Byte Read
2'b11 : SMBus Block Read</spirit:description>
                  <spirit:bitOffset>2</spirit:bitOffset>
                  <spirit:bitWidth>2</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>clock_stretch_en</spirit:name>
                  <spirit:description>Clock stretch enable</spirit:description>
                  <spirit:bitOffset>1</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>1</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>go</spirit:name>
                  <spirit:description>Write a 1 to initiate an I2C transaction. HW will clear this field upon completion and also generates an interrupt. A new transaction should not be attempted until this field returns a 0, indicating it is not busy.
</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                     <ids_properties>
                        <rtl.hw_clear>1</rtl.hw_clear>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x8000060C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>wr_data</spirit:name>
               <spirit:description>I2C write data</spirit:description>
               <spirit:addressOffset>0x10</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>wr_data</spirit:name>
                  <spirit:description>Byte to write into the I2C master FIFO.
</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>write-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                     <ids_properties>
                        <rtl.hw_wp>1</rtl.hw_wp>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000610</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>rd_data</spirit:name>
               <spirit:description>I2C read data</spirit:description>
               <spirit:addressOffset>0x14</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>rd_data</spirit:name>
                  <spirit:description>Byte to read from the I2C master FIFO.
</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                     <ids_properties>
                        <rtl.hw_rp>1</rtl.hw_rp>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000614</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>
  <!-- reg group
                    :irq  --> 
          <spirit:registerFile>
               <spirit:name>irq</spirit:name>
               <spirit:description>I2C Master Interrupt register group</spirit:description>
               <spirit:addressOffset>0x18</spirit:addressOffset>
               <spirit:range>0x10</spirit:range>            
               <spirit:register>
                  <spirit:name>enable</spirit:name>
                  <spirit:description>Interrupt Enable register - Write 1 to enable, 0 to mask an interrupt
</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>fifo_ae</spirit:name>
                     <spirit:description>FIFO almost empty
NOTE: If the FIFO is empty when this interrupt is enabled, it will cause an interrupt right away!</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_af</spirit:name>
                     <spirit:description>FIFO almost full</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>done</spirit:name>
                     <spirit:description>Transfer done</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000618</address>
                        <intr.enable>irq0_i2c_master</intr.enable>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending</spirit:name>
                  <spirit:description>Pending register - This indicates which events are pending, Write 1 to clear
</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>fifo_ae</spirit:name>
                     <spirit:description>Level-triggered - Active High
FIFO almost empty
NOTE: If the FIFO is empty, this event is pending and if enabled will cause an interrupt!</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_af</spirit:name>
                     <spirit:description>Level-triggered - Active-High
FIFO almost full</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>done</spirit:name>
                     <spirit:description>Edge-triggered - Active High
Transfer done</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000061C</address>
                        <intr.status>irq0_i2c_master</intr.status>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending_irq</spirit:name>
                  <spirit:description>Interrupt Pending register - This indicates which pending events are enabled to cause an interrupt
</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>fifo_ae</spirit:name>
                     <spirit:description>Level-triggered - Active High
FIFO almost empty</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_af</spirit:name>
                     <spirit:description>Level-triggered - Active-High
FIFO almost full</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>done</spirit:name>
                     <spirit:description>Edge-triggered - Active High
Transfer done</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000620</address>
                        <intr.pending>irq0_i2c_master</intr.pending>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>raw</spirit:name>
                  <spirit:description>This register contains the registered state of interrupt signals</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>fifo_ae</spirit:name>
                     <spirit:description>Current state of the FIFO almost empty flag (Active-High)</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_af</spirit:name>
                     <spirit:description>Current state of the FIFO almost full flag (Active-High)</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>done</spirit:name>
                     <spirit:description>Current state of the transfer done flag (Active-High)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000624</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000618</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : irq  --> 
         <spirit:vendorExtensions>
               <ids_properties>
                  <module_name>i2c_master_regs</module_name>
                  <uvm.package>i2c_master_regs_pkg</uvm.package>
                  <reset_type>async</reset_type>
                  <cheader.mask_endianess>little</cheader.mask_endianess>
                  <header.struct_guard>__ASSEMBLER__</header.struct_guard>
                  <explicit_name>true</explicit_name>
                  <vertical_reuse>true</vertical_reuse>
                  <address>0x80000600</address>
               </ids_properties>
            </spirit:vendorExtensions>
         </spirit:addressBlock>     
         <spirit:addressBlock>     
            <spirit:name>i2c_slave</spirit:name>
            <spirit:description>I2C Slave
</spirit:description>  <!-- //
                        block : i2c_slave  --> 
            <spirit:baseAddress>0x80000700</spirit:baseAddress>               
            <spirit:range>0x100</spirit:range>               
            <spirit:width>32</spirit:width>            
            <spirit:register>
               <spirit:name>version</spirit:name>
               <spirit:description>Version</spirit:description>
               <spirit:addressOffset>0x0</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00040001</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>major</spirit:name>
                  <spirit:description>Major version</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000100</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>minor</spirit:name>
                  <spirit:description>Minor version</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>patch</spirit:name>
                  <spirit:description>Patch version</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000001</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000700</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>in_fifo</spirit:name>
               <spirit:description>Input FIFO control and status</spirit:description>
               <spirit:addressOffset>0x4</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>fifo_clear</spirit:name>
                  <spirit:description>FIFO clear
</spirit:description>
                  <spirit:bitOffset>31</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                     <ids_properties>
                        <rtl.hw_wp>1</rtl.hw_wp>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_af</spirit:name>
                  <spirit:description>FIFO almost full status field. A 1 indicates an almost full or full FIFO. This bit is set when there are between fifo_aft and fifo_depth number of entries in the FIFO.</spirit:description>
                  <spirit:bitOffset>27</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_ae</spirit:name>
                  <spirit:description>FIFO almost empty status field. A 1 indicates an almost empty or empty FIFO. This bit is set when there are between 0 and fifo_aet number of entries in the FIFO.</spirit:description>
                  <spirit:bitOffset>26</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_full</spirit:name>
                  <spirit:description>FIFO full status field. A 1 indicates a full FIFO.</spirit:description>
                  <spirit:bitOffset>25</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_empty</spirit:name>
                  <spirit:description>FIFO empty status field. A 1 indicates an empty FIFO.</spirit:description>
                  <spirit:bitOffset>24</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_aft</spirit:name>
                  <spirit:description>FIFO almost full threshold</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_aet</spirit:name>
                  <spirit:description>FIFO almost empty threshold</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_depth</spirit:name>
                  <spirit:description>FIFO depth (always 1 byte wide)</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000704</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>out_fifo</spirit:name>
               <spirit:description>Output FIFO control and status</spirit:description>
               <spirit:addressOffset>0x8</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>fifo_clear</spirit:name>
                  <spirit:description>FIFO clear
</spirit:description>
                  <spirit:bitOffset>31</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                     <ids_properties>
                        <rtl.hw_wp>1</rtl.hw_wp>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_af</spirit:name>
                  <spirit:description>FIFO almost full status field. A 1 indicates an almost full or full FIFO. This bit is set when there are between fifo_aft and fifo_depth number of entries in the FIFO.</spirit:description>
                  <spirit:bitOffset>27</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_ae</spirit:name>
                  <spirit:description>FIFO almost empty status field. A 1 indicates an almost empty or empty FIFO. This bit is set when there are between 0 and fifo_aet number of entries in the FIFO.</spirit:description>
                  <spirit:bitOffset>26</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_full</spirit:name>
                  <spirit:description>FIFO full status field. A 1 indicates a full FIFO.</spirit:description>
                  <spirit:bitOffset>25</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_empty</spirit:name>
                  <spirit:description>FIFO empty status field. A 1 indicates an empty FIFO.</spirit:description>
                  <spirit:bitOffset>24</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_aft</spirit:name>
                  <spirit:description>FIFO almost full threshold</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_aet</spirit:name>
                  <spirit:description>FIFO almost empty threshold</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_depth</spirit:name>
                  <spirit:description>FIFO depth (always 1 byte wide)</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000708</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>slave_config</spirit:name>
               <spirit:description>Config</spirit:description>
               <spirit:addressOffset>0xC</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000008</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>no_device_busy</spirit:name>
                  <spirit:description>Prevent HW setting device_busy</spirit:description>
                  <spirit:bitOffset>30</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>no_reply_data_rdy</spirit:name>
                  <spirit:description>Prevent HW clearing the reply_data_rdy</spirit:description>
                  <spirit:bitOffset>29</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>no_status</spirit:name>
                  <spirit:description>Do not send the status byte</spirit:description>
                  <spirit:bitOffset>28</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>stop_clks</spirit:name>
                  <spirit:description>Declare a start (P) if there were at least stop_clks + 2 clock cycles between the SCL rising edge and the SDA rising edge</spirit:description>
                  <spirit:bitOffset>24</spirit:bitOffset>
                  <spirit:bitWidth>4</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>start_clks</spirit:name>
                  <spirit:description>Declare a start (S) if there were at least start_clks + 2 clock cycles between the SDA falling edge and the SCL falling edge</spirit:description>
                  <spirit:bitOffset>20</spirit:bitOffset>
                  <spirit:bitWidth>4</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>sda_glitch</spirit:name>
                  <spirit:description>Filter glitches up to this number + 1 clock cycles on the SDA line</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>4</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>scl_glitch</spirit:name>
                  <spirit:description>Filter glitches up to this number + 1 clock cycles on the SCL line</spirit:description>
                  <spirit:bitOffset>12</spirit:bitOffset>
                  <spirit:bitWidth>4</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>clock_stretch_en</spirit:name>
                  <spirit:description>Enable clock stretching - Active High</spirit:description>
                  <spirit:bitOffset>9</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>slave_addr_ack</spirit:name>
                  <spirit:description>Slave address ACK - Active High</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>slave_addr</spirit:name>
                  <spirit:description>Slave address</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>7</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0001000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x8000070C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>timeout</spirit:name>
               <spirit:description>Timeout</spirit:description>
               <spirit:addressOffset>0x10</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>val</spirit:name>
                  <spirit:description>Timeout value in number of clock cycles (SMBus)
A value of 0x0 disables the timeout (I2C)</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>32</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000000000000000000000000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000710</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>status</spirit:name>
               <spirit:description>Status</spirit:description>
               <spirit:addressOffset>0x14</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000080</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>device_busy</spirit:name>
                  <spirit:description>Device Busy - set by the hardware at the end of a transaction by the Master that writes to the request data area. Cleared by the slave CPU when it has read the data and responded to the command.</spirit:description>
                  <spirit:bitOffset>7</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>1</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>req_nak</spirit:name>
                  <spirit:description>Request NAK - set by the slave if a request could not be filled; the reply data will need to be read before the hardware will clear this bit (same as Reply Data Ready)</spirit:description>
                  <spirit:bitOffset>6</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>rsvd5</spirit:name>
                  <spirit:description>Reserved for SW</spirit:description>
                  <spirit:bitOffset>5</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>rsvd4</spirit:name>
                  <spirit:description>Reserved for SW</spirit:description>
                  <spirit:bitOffset>4</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>reply_data_rdy</spirit:name>
                  <spirit:description>Reply Data Ready - set by SW when data is ready for the master; cleared by HW when the output FIFO is empty
</spirit:description>
                  <spirit:bitOffset>3</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                     <ids_properties>
                        <rtl.hw_clear>1</rtl.hw_clear>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>reply_req</spirit:name>
                  <spirit:description>Reply Request - indicates the type of data the slave has for the master. If set, the data is a reply to a previous request from the master. If cleared, this is unsolicited status information the slave has for the master</spirit:description>
                  <spirit:bitOffset>2</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>rsvd1</spirit:name>
                  <spirit:description>Reserved for SW</spirit:description>
                  <spirit:bitOffset>1</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>rsvd0</spirit:name>
                  <spirit:description>Reserved for SW</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000714</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>wr_data</spirit:name>
               <spirit:description>Write data</spirit:description>
               <spirit:addressOffset>0x18</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>wr_data</spirit:name>
                  <spirit:description>Byte to write into the output FIFO.
</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>write-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                     <ids_properties>
                        <rtl.hw_wp>1</rtl.hw_wp>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000718</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>rd_data</spirit:name>
               <spirit:description>Read data</spirit:description>
               <spirit:addressOffset>0x1C</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>rd_data</spirit:name>
                  <spirit:description>Byte to read from the input FIFO.
</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                     <ids_properties>
                        <rtl.hw_rp>1</rtl.hw_rp>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x8000071C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>
  <!-- reg group
                    :irq  --> 
          <spirit:registerFile>
               <spirit:name>irq</spirit:name>
               <spirit:description>Interrupt register group</spirit:description>
               <spirit:addressOffset>0x20</spirit:addressOffset>
               <spirit:range>0x10</spirit:range>            
               <spirit:register>
                  <spirit:name>enable</spirit:name>
                  <spirit:description>Interrupt Enable register - Write 1 to enable, 0 to mask an interrupt
</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>reply_data_rdy</spirit:name>
                     <spirit:description>Reply data ready</spirit:description>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>device_busy</spirit:name>
                     <spirit:description>Device busy</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>out_fifo_af</spirit:name>
                     <spirit:description>Output FIFO almost full</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>out_fifo_ae</spirit:name>
                     <spirit:description>Output FIFO almost empty
NOTE: If the FIFO is empty when this interrupt is enabled, it will cause an interrupt right away!</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_fifo_af</spirit:name>
                     <spirit:description>Input FIFO almost full</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_fifo_ae</spirit:name>
                     <spirit:description>Input FIFO almost empty
NOTE: If the FIFO is empty when this interrupt is enabled, it will cause an interrupt right away!</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>write_nack</spirit:name>
                     <spirit:description>Write data was NACK-ed by the slave</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>read_nack</spirit:name>
                     <spirit:description>Read data was NACK-ed by the master</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>no_read_data</spirit:name>
                     <spirit:description>Read data is requested but there is no data to provide (slave is clock stretching if enabled or else returning all 1s)</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>timeout</spirit:name>
                     <spirit:description>SCL was low for timeout.val module clock cycles</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>write</spirit:name>
                     <spirit:description>The bit after an acknowledged slave address indicates a write operation</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>read</spirit:name>
                     <spirit:description>The bit after an acknowledged slave address indicates a read operation</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>stop</spirit:name>
                     <spirit:description>Stop bit detected</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>start</spirit:name>
                     <spirit:description>Start or Repeated Start bit detected</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000720</address>
                        <intr.enable>irq0_i2c_slave</intr.enable>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending</spirit:name>
                  <spirit:description>Pending register - This indicates which events are pending, Write 1 to clear
</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>reply_data_rdy</spirit:name>
                     <spirit:description>Edge-triggered - Active-High
Reply data ready</spirit:description>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>device_busy</spirit:name>
                     <spirit:description>Edge-triggered - Active-High
Device busy</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>out_fifo_af</spirit:name>
                     <spirit:description>Level-triggered - Active-High
Output FIFO almost full</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>out_fifo_ae</spirit:name>
                     <spirit:description>Level-triggered - Active High
Output FIFO almost empty
NOTE: If the FIFO is empty, this event is pending and if enabled will cause an interrupt!</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_fifo_af</spirit:name>
                     <spirit:description>Level-triggered - Active-High
Input FIFO almost full</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_fifo_ae</spirit:name>
                     <spirit:description>Level-triggered - Active High
Input FIFO almost empty
NOTE: If the FIFO is empty, this event is pending and if enabled will cause an interrupt!</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>write_nack</spirit:name>
                     <spirit:description>Edge-triggered - Active-High
Write NACK</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>read_nack</spirit:name>
                     <spirit:description>Edge-triggered - Active-High
Read NACK</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>no_read_data</spirit:name>
                     <spirit:description>Edge-triggered - Active-High
No Read Data</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>timeout</spirit:name>
                     <spirit:description>Edge-triggered - Active-High
Timeout</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>write</spirit:name>
                     <spirit:description>Edge-triggered - Active-High
Write</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>read</spirit:name>
                     <spirit:description>Edge-triggered - Active-High
Read</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>stop</spirit:name>
                     <spirit:description>Edge-triggered - Active-High
Stop</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>start</spirit:name>
                     <spirit:description>Edge-triggered - Active-High
Start</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000724</address>
                        <intr.status>irq0_i2c_slave</intr.status>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending_irq</spirit:name>
                  <spirit:description>Interrupt Pending register - This indicates which pending events are enabled to cause an interrupt
</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>reply_data_rdy</spirit:name>
                     <spirit:description>Edge-triggered - Active-High
Reply data ready</spirit:description>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>device_busy</spirit:name>
                     <spirit:description>Edge-triggered - Active-High
Device busy</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>out_fifo_af</spirit:name>
                     <spirit:description>Level-triggered - Active-High
Output FIFO almost full</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>out_fifo_ae</spirit:name>
                     <spirit:description>Level-triggered - Active High
Output FIFO almost empty</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_fifo_af</spirit:name>
                     <spirit:description>Level-triggered - Active-High
Input FIFO almost full</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_fifo_ae</spirit:name>
                     <spirit:description>Level-triggered - Active High
Input FIFO almost empty</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>write_nack</spirit:name>
                     <spirit:description>Edge-triggered - Active-High
Write NACK</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>read_nack</spirit:name>
                     <spirit:description>Edge-triggered - Active-High
Read NACK</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>no_read_data</spirit:name>
                     <spirit:description>Edge-triggered - Active-High
No Read Data</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>timeout</spirit:name>
                     <spirit:description>Edge-triggered - Active-High
Timeout</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>write</spirit:name>
                     <spirit:description>Edge-triggered - Active-High
Write</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>read</spirit:name>
                     <spirit:description>Edge-triggered - Active-High
Read</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>stop</spirit:name>
                     <spirit:description>Edge-triggered - Active-High
Stop</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>start</spirit:name>
                     <spirit:description>Edge-triggered - Active-High
Start</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000728</address>
                        <intr.pending>irq0_i2c_slave</intr.pending>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>raw</spirit:name>
                  <spirit:description>This register contains the registered state of interrupt signals</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>reply_data_rdy</spirit:name>
                     <spirit:description>Current state of the reply data ready flag (Active-High)</spirit:description>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>device_busy</spirit:name>
                     <spirit:description>Current state of the device busy flag (Active-High)</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>out_fifo_af</spirit:name>
                     <spirit:description>Current state of the output FIFO almost full flag (Active-High)</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>out_fifo_ae</spirit:name>
                     <spirit:description>Current state of the output FIFO almost empty flag (Active-High)</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_fifo_af</spirit:name>
                     <spirit:description>Current state of the input FIFO almost full flag (Active-High)</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_fifo_ae</spirit:name>
                     <spirit:description>Current state of the input FIFO almost empty flag (Active-High)</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>write_nack</spirit:name>
                     <spirit:description>Current state of the write nack flag (Active-High)</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>read_nack</spirit:name>
                     <spirit:description>Current state of the read nack flag (Active-High)</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>no_read_data</spirit:name>
                     <spirit:description>Current state of the no read data flag (Active-High)</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>timeout</spirit:name>
                     <spirit:description>Current state of the timeout flag (Active-High)</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>write</spirit:name>
                     <spirit:description>Current state of the write flag (Active-High)</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>read</spirit:name>
                     <spirit:description>Current state of the read flag (Active-High)</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>stop</spirit:name>
                     <spirit:description>Current state of the stop flag (Active-High)</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>start</spirit:name>
                     <spirit:description>Current state of the start flag (Active-High)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000072C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000720</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : irq  --> 
         <spirit:vendorExtensions>
               <ids_properties>
                  <module_name>i2c_slave_regs</module_name>
                  <uvm.package>i2c_slave_regs_pkg</uvm.package>
                  <reset_type>async</reset_type>
                  <cheader.mask_endianess>little</cheader.mask_endianess>
                  <header.struct_guard>__ASSEMBLER__</header.struct_guard>
                  <explicit_name>true</explicit_name>
                  <vertical_reuse>true</vertical_reuse>
                  <address>0x80000700</address>
               </ids_properties>
            </spirit:vendorExtensions>
         </spirit:addressBlock>     
         <spirit:addressBlock>     
            <spirit:name>mdio_master</spirit:name>
            <spirit:description>MDIO Master
</spirit:description>  <!-- //
                        block : mdio_master  --> 
            <spirit:baseAddress>0x80000800</spirit:baseAddress>               
            <spirit:range>0x100</spirit:range>               
            <spirit:width>32</spirit:width>            
            <spirit:register>
               <spirit:name>version</spirit:name>
               <spirit:description>Version</spirit:description>
               <spirit:addressOffset>0x0</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00030001</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>major</spirit:name>
                  <spirit:description>Major version</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000011</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>minor</spirit:name>
                  <spirit:description>Minor version</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>patch</spirit:name>
                  <spirit:description>Patch version</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000001</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000800</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>timing</spirit:name>
               <spirit:description>MDIO timing</spirit:description>
               <spirit:addressOffset>0x4</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>hold_clks</spirit:name>
                  <spirit:description>Hold time in clock cycles</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>setup_clks</spirit:name>
                  <spirit:description>Setup time in clock cycles</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>half_mdc_clks</spirit:name>
                  <spirit:description>Half MDC period in clock cycles</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000804</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>control</spirit:name>
               <spirit:description>MDIO control</spirit:description>
               <spirit:addressOffset>0x8</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>phyad</spirit:name>
                  <spirit:description>PHY Address</spirit:description>
                  <spirit:bitOffset>20</spirit:bitOffset>
                  <spirit:bitWidth>5</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>regad</spirit:name>
                  <spirit:description>Register Address (ST &lt;01&gt;) / Device Type (ST &lt;00&gt;)</spirit:description>
                  <spirit:bitOffset>12</spirit:bitOffset>
                  <spirit:bitWidth>5</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>op</spirit:name>
                  <spirit:description>Operation Code:
ST &lt;00&gt;:
2'b00 : Address
2'b01 : Write
2'b10 : Post-Read-Increment-Address
2'b11 : Read

ST &lt;01&gt;:
2'b00 : Reserved
2'b01 : Write
2'b10 : Read
2'b11 : Reserved</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>2</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>st</spirit:name>
                  <spirit:description>Start of Frame pattern:
2'b00 : Clause 45 of IEEE 802.3 (Indirect Address)
2'b01 : Clause 22 of IEEE 802.3 (Direct Address)</spirit:description>
                  <spirit:bitOffset>4</spirit:bitOffset>
                  <spirit:bitWidth>2</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>go</spirit:name>
                  <spirit:description>Write a 1 to initiate an MDIO transaction. HW will clear this field upon completion and also generates an interrupt. A new transaction should not be attempted until this field returns a 0, indicating it is not busy.
</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                     <ids_properties>
                        <rtl.hw_clear>1</rtl.hw_clear>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000808</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>wr_data</spirit:name>
               <spirit:description>MDIO write data</spirit:description>
               <spirit:addressOffset>0xC</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>wr_data</spirit:name>
                  <spirit:description>MDIO Write Data</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>16</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0000000000000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x8000080C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>rd_data</spirit:name>
               <spirit:description>MDIO read data</spirit:description>
               <spirit:addressOffset>0x10</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>rd_data</spirit:name>
                  <spirit:description>MDIO Read Data</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>16</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0000000000000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000810</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>
  <!-- reg group
                    :irq  --> 
          <spirit:registerFile>
               <spirit:name>irq</spirit:name>
               <spirit:description>MDIO Master Interrupt register group</spirit:description>
               <spirit:addressOffset>0x14</spirit:addressOffset>
               <spirit:range>0x10</spirit:range>            
               <spirit:register>
                  <spirit:name>enable</spirit:name>
                  <spirit:description>Interrupt Enable register - Write 1 to enable, 0 to mask an interrupt
</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>done</spirit:name>
                     <spirit:description>Transfer done</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000814</address>
                        <intr.enable>irq0_mdio_master</intr.enable>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending</spirit:name>
                  <spirit:description>Pending register - This indicates which events are pending, Write 1 to clear
</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>done</spirit:name>
                     <spirit:description>Edge-triggered - Active High
Transfer done</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000818</address>
                        <intr.status>irq0_mdio_master</intr.status>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending_irq</spirit:name>
                  <spirit:description>Interrupt Pending register - This indicates which pending events are enabled to cause an interrupt
</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>done</spirit:name>
                     <spirit:description>Edge-triggered - Active High
Transfer done</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000081C</address>
                        <intr.pending>irq0_mdio_master</intr.pending>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>raw</spirit:name>
                  <spirit:description>This register contains the registered state of interrupt signals</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>done</spirit:name>
                     <spirit:description>Current state of the transfer done flag (Active-High)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000820</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000814</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : irq  --> 
         <spirit:vendorExtensions>
               <ids_properties>
                  <module_name>mdio_master_regs</module_name>
                  <uvm.package>mdio_master_regs_pkg</uvm.package>
                  <reset_type>async</reset_type>
                  <cheader.mask_endianess>little</cheader.mask_endianess>
                  <header.struct_guard>__ASSEMBLER__</header.struct_guard>
                  <explicit_name>true</explicit_name>
                  <vertical_reuse>true</vertical_reuse>
                  <address>0x80000800</address>
               </ids_properties>
            </spirit:vendorExtensions>
         </spirit:addressBlock>     
         <spirit:addressBlock>     
            <spirit:name>spi_flash_ctrl</spirit:name>
            <spirit:description>SPI Flash Controller
</spirit:description>  <!-- //
                        block : spi_flash_ctrl  --> 
            <spirit:baseAddress>0x80000900</spirit:baseAddress>               
            <spirit:range>0x100</spirit:range>               
            <spirit:width>32</spirit:width>            
            <spirit:register>
               <spirit:name>version</spirit:name>
               <spirit:description>Version</spirit:description>
               <spirit:addressOffset>0x0</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00020203</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>major</spirit:name>
                  <spirit:description>Major version</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000010</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>minor</spirit:name>
                  <spirit:description>Minor version</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000010</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>patch</spirit:name>
                  <spirit:description>Patch version</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000011</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000900</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>generic_cfg</spirit:name>
               <spirit:description>Basic Configuration</spirit:description>
               <spirit:addressOffset>0x4</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00FF1212</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>sck_freerun</spirit:name>
                  <spirit:description>SCK Freerun (Active-High)</spirit:description>
                  <spirit:bitOffset>31</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>io_out_defaults</spirit:name>
                  <spirit:description>Output value for each IO when not active</spirit:description>
                  <spirit:bitOffset>20</spirit:bitOffset>
                  <spirit:bitWidth>4</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>1111</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>io_tri_defaults</spirit:name>
                  <spirit:description>Tri-State value for each IO when not active</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>4</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>1111</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>sck_oe_deassert_cfg</spirit:name>
                  <spirit:description>SCK OE deassert configuration
0 : one cycle before last action finish
 1 : aligned with last action finish
 2-15 : n-1 (1-14) cycles after last action finish</spirit:description>
                  <spirit:bitOffset>12</spirit:bitOffset>
                  <spirit:bitWidth>4</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0001</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>cs_deassert_cfg</spirit:name>
                  <spirit:description>CS deassert configuration
0 : one cycle before last action finish
 1 : aligned with last action finish
 2-15 : n-1 (1-14) cycles after last action finish</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>4</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0010</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>sck_oe_assert_cfg</spirit:name>
                  <spirit:description>SCK OE assert configuration
0 : one cycle after first action start
1 : aligned with first action start
2-15 : n-1 (1-14) cycles before first action start</spirit:description>
                  <spirit:bitOffset>4</spirit:bitOffset>
                  <spirit:bitWidth>4</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0001</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>cs_assert_cfg</spirit:name>
                  <spirit:description>CS assert configuration
0 : one cycle after first action start
1 : aligned with first action start
2-15 : n-1 (1-14) cycles before first action start</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>4</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0010</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000904</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>addr_offset</spirit:name>
               <spirit:description>Address Offset</spirit:description>
               <spirit:addressOffset>0x8</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>val</spirit:name>
                  <spirit:description>Address Offset - This is the offset from the address</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>32</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000000000000000000000000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000908</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>addr</spirit:name>
               <spirit:description>Address</spirit:description>
               <spirit:addressOffset>0xC</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>val</spirit:name>
                  <spirit:description>Address</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>32</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000000000000000000000000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x8000090C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>basic_cfg</spirit:name>
               <spirit:description>Basic Configuration</spirit:description>
               <spirit:addressOffset>0x10</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000211</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>tr_gap_p3</spirit:name>
                  <spirit:description>Minimum number of SPI clock cycles + 3 that CS should be deasserted after a command</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>16</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0000000000000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>io_mask_data</spirit:name>
                  <spirit:description>IO mask for the data
- 0 means no data</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>4</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0010</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>io_mask_addr</spirit:name>
                  <spirit:description>IO mask for the address
- 0 means no address</spirit:description>
                  <spirit:bitOffset>4</spirit:bitOffset>
                  <spirit:bitWidth>4</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0001</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>io_mask_cmd</spirit:name>
                  <spirit:description>IO mask for the command
- 0 means no command</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>4</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0001</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000910</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>control</spirit:name>
               <spirit:description>Control</spirit:description>
               <spirit:addressOffset>0x14</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x0008000B</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>go</spirit:name>
                  <spirit:description>Write a 1 to initiate a SPI transaction. HW will clear this field upon completion and also generate an interrupt. A new transaction should not be attempted until this field returns a 0, indicating it is not busy.
</spirit:description>
                  <spirit:bitOffset>31</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                     <ids_properties>
                        <rtl.hw_clear>1</rtl.hw_clear>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>addr_mode</spirit:name>
                  <spirit:description>Address mode
0 : 3-bytes
1 : 4-bytes</spirit:description>
                  <spirit:bitOffset>25</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>write</spirit:name>
                  <spirit:description>Read or Write Data (only used if io_mask_data != 0)
0 : Read Data
1 : Write Data</spirit:description>
                  <spirit:bitOffset>24</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>num_dummy_clks</spirit:name>
                  <spirit:description>Number of dummy clock cycles
- 0 means no dummy clock cycles</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>7</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0001000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>num_bytes</spirit:name>
                  <spirit:description>Number of data bytes (0 stops when FIFO is full/empty)</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>cmd</spirit:name>
                  <spirit:description>Command</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00001011</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000914</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>wr_data</spirit:name>
               <spirit:description>Write data</spirit:description>
               <spirit:addressOffset>0x18</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>val</spirit:name>
                  <spirit:description>Word to write into the output FIFO.
</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>32</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>write-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000000000000000000000000000</ids:default_value>
                     <ids_properties>
                        <rtl.hw_wp>1</rtl.hw_wp>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000918</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>rd_data</spirit:name>
               <spirit:description>Read data</spirit:description>
               <spirit:addressOffset>0x1C</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>val</spirit:name>
                  <spirit:description>Word to read from the input FIFO.
</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>32</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000000000000000000000000000</ids:default_value>
                     <ids_properties>
                        <rtl.hw_rp>1</rtl.hw_rp>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x8000091C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>in_fifo</spirit:name>
               <spirit:description>Input FIFO control and status</spirit:description>
               <spirit:addressOffset>0x20</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>fifo_clear</spirit:name>
                  <spirit:description>FIFO clear
</spirit:description>
                  <spirit:bitOffset>31</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                     <ids_properties>
                        <rtl.hw_wp>1</rtl.hw_wp>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_af</spirit:name>
                  <spirit:description>FIFO almost full status field. A 1 indicates an almost full or full FIFO. This bit is set when there are between fifo_aft and fifo_depth number of entries in the FIFO.</spirit:description>
                  <spirit:bitOffset>27</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_ae</spirit:name>
                  <spirit:description>FIFO almost empty status field. A 1 indicates an almost empty or empty FIFO. This bit is set when there are between 0 and fifo_aet number of entries in the FIFO.</spirit:description>
                  <spirit:bitOffset>26</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_full</spirit:name>
                  <spirit:description>FIFO full status field. A 1 indicates a full FIFO.</spirit:description>
                  <spirit:bitOffset>25</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_empty</spirit:name>
                  <spirit:description>FIFO empty status field. A 1 indicates an empty FIFO.</spirit:description>
                  <spirit:bitOffset>24</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_aft</spirit:name>
                  <spirit:description>FIFO almost full threshold</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_aet</spirit:name>
                  <spirit:description>FIFO almost empty threshold</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_depth</spirit:name>
                  <spirit:description>FIFO depth (always 4 bytes wide)</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000920</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>out_fifo</spirit:name>
               <spirit:description>Output FIFO control and status</spirit:description>
               <spirit:addressOffset>0x24</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>fifo_clear</spirit:name>
                  <spirit:description>FIFO clear
</spirit:description>
                  <spirit:bitOffset>31</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                     <ids_properties>
                        <rtl.hw_wp>1</rtl.hw_wp>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_af</spirit:name>
                  <spirit:description>FIFO almost full status field. A 1 indicates an almost full or full FIFO. This bit is set when there are between fifo_aft and fifo_depth number of entries in the FIFO.</spirit:description>
                  <spirit:bitOffset>27</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_ae</spirit:name>
                  <spirit:description>FIFO almost empty status field. A 1 indicates an almost empty or empty FIFO. This bit is set when there are between 0 and fifo_aet number of entries in the FIFO.</spirit:description>
                  <spirit:bitOffset>26</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_full</spirit:name>
                  <spirit:description>FIFO full status field. A 1 indicates a full FIFO.</spirit:description>
                  <spirit:bitOffset>25</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_empty</spirit:name>
                  <spirit:description>FIFO empty status field. A 1 indicates an empty FIFO.</spirit:description>
                  <spirit:bitOffset>24</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_aft</spirit:name>
                  <spirit:description>FIFO almost full threshold</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_aet</spirit:name>
                  <spirit:description>FIFO almost empty threshold</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_depth</spirit:name>
                  <spirit:description>FIFO depth (always 4 bytes wide)</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000924</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>
  <!-- reg group
                    :mm  --> 
          <spirit:registerFile>
               <spirit:name>mm</spirit:name>
               <spirit:description>Memory Mapped register group</spirit:description>
               <spirit:addressOffset>0x28</spirit:addressOffset>
               <spirit:range>0x10</spirit:range>            
               <spirit:register>
                  <spirit:name>addr_offset</spirit:name>
                  <spirit:description>Address Offset</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>val</spirit:name>
                     <spirit:description>Address Offset - This is the offset from the address</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>32</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000000000000000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000928</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>basic_cfg</spirit:name>
                  <spirit:description>Basic Configuration</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x08F2110B</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>addr_mode</spirit:name>
                     <spirit:description>Address mode
0 : 3-bytes
1 : 4-bytes</spirit:description>
                     <spirit:bitOffset>31</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>num_dummy_clks</spirit:name>
                     <spirit:description>Number of dummy clock cycles
- 0 means no dummy clock cycles</spirit:description>
                     <spirit:bitOffset>24</spirit:bitOffset>
                     <spirit:bitWidth>7</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0001000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tr_gap_p3</spirit:name>
                     <spirit:description>Minimum number of SPI clock cycles + 3 that CS should be deasserted after a read command</spirit:description>
                     <spirit:bitOffset>20</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1111</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>io_mask_data</spirit:name>
                     <spirit:description>IO mask for the read data</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0010</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>io_mask_addr</spirit:name>
                     <spirit:description>IO mask for the address</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0001</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>io_mask_cmd</spirit:name>
                     <spirit:description>IO mask for the read command</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0001</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>read_cmd</spirit:name>
                     <spirit:description>Read command</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00001011</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000092C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>xip_cfg</spirit:name>
                  <spirit:description>eXecute In Place Configuration</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00100000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>xip_en</spirit:name>
                     <spirit:description>XIP Enable
- The first read transaction following the assertion of this bit will have the basic_cfg.read_cmd and xip_cfg.mode_xip bits
- Following read transactions will not have a read command and will use xip_cfg.mode_xip bits
- The read transaction following the de-assertion of this bit will not have a read command and use xip_cfg.mode_normal bits
- Following read transactions will use basic_cfg.read_cmd and xip_cfg.mode_normal bits (Default)</spirit:description>
                     <spirit:bitOffset>31</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>io_mask_mode</spirit:name>
                     <spirit:description>IO Mask for the mode bits</spirit:description>
                     <spirit:bitOffset>20</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0001</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>num_mode_bits</spirit:name>
                     <spirit:description>Number of mode bits to send
- 0 means no mode bits are sent
- 8 is the maximum</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mode_xip</spirit:name>
                     <spirit:description>Mode bits when there is no command (XIP mode)</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mode_normal</spirit:name>
                     <spirit:description>Mode bits when there is an command (normal read mode)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000930</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>suspend_cfg</spirit:name>
                  <spirit:description>Suspend Configuration</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000175</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>tr_gap_p3</spirit:name>
                     <spirit:description>Minimum number of SPI clock cycles + 3 that CS should be deasserted after suspend command</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>enable</spirit:name>
                     <spirit:description>This should be set by SW when a suspend command should be executed before an incoming read request can be handled. This would be the case if a program or erase is in progress.
This bit gets cleared as soon as the suspend command is executed.
</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <rtl.hw_clear>1</rtl.hw_clear>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>io_mask</spirit:name>
                     <spirit:description>IO Mask for the suspend command</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0001</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>cmd</spirit:name>
                     <spirit:description>Suspend command</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>01110101</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000934</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000928</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : mm  --> 

  <!-- reg group
                    :irq  --> 
          <spirit:registerFile>
               <spirit:name>irq</spirit:name>
               <spirit:description>SPI Flash Controller Interrupt register group</spirit:description>
               <spirit:addressOffset>0x38</spirit:addressOffset>
               <spirit:range>0x10</spirit:range>            
               <spirit:register>
                  <spirit:name>enable</spirit:name>
                  <spirit:description>Interrupt Enable register - Write 1 to enable, 0 to mask an interrupt
</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>apb_tr_done</spirit:name>
                     <spirit:description>APB SPI Flash transaction done</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>out_fifo_af</spirit:name>
                     <spirit:description>Output FIFO almost full</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>out_fifo_ae</spirit:name>
                     <spirit:description>Output FIFO almost empty
NOTE: If the FIFO is empty when this interrupt is enabled, it will cause an interrupt right away!</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_fifo_af</spirit:name>
                     <spirit:description>Input FIFO almost full</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_fifo_ae</spirit:name>
                     <spirit:description>Input FIFO almost empty interrupt mask - Write 1 to enable
NOTE: If the FIFO is empty when this interrupt is enabled, it will cause an interrupt right away!</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000938</address>
                        <intr.enable>irq0_spi_flash_ctrl</intr.enable>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending</spirit:name>
                  <spirit:description>Pending register - This indicates which events are pending, Write 1 to clear
</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>apb_tr_done</spirit:name>
                     <spirit:description>Level-triggered - Active-High
APB SPI Flash transaction done</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>out_fifo_af</spirit:name>
                     <spirit:description>Level-triggered - Active-High
Output FIFO almost full</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>out_fifo_ae</spirit:name>
                     <spirit:description>Level-triggered - Active High
Output FIFO almost empty
NOTE: If the FIFO is empty, this event is pending and if enabled will cause an interrupt!</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_fifo_af</spirit:name>
                     <spirit:description>Level-triggered - Active-High
Input FIFO almost full</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_fifo_ae</spirit:name>
                     <spirit:description>Level-triggered - Active High
Input FIFO almost empty
NOTE: If the FIFO is empty, this event is pending and if enabled will cause an interrupt!</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000093C</address>
                        <intr.status>irq0_spi_flash_ctrl</intr.status>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending_irq</spirit:name>
                  <spirit:description>Interrupt Pending register - This indicates which pending events are enabled to cause an interrupt
</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>apb_tr_done</spirit:name>
                     <spirit:description>Level-triggered - Active-High
APB SPI Flash transaction done</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>out_fifo_af</spirit:name>
                     <spirit:description>Level-triggered - Active-High
Output FIFO almost full</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>out_fifo_ae</spirit:name>
                     <spirit:description>Level-triggered - Active High
Output FIFO almost empty</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_fifo_af</spirit:name>
                     <spirit:description>Level-triggered - Active-High
Input FIFO almost full</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_fifo_ae</spirit:name>
                     <spirit:description>Level-triggered - Active High
Input FIFO almost empty</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000940</address>
                        <intr.pending>irq0_spi_flash_ctrl</intr.pending>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>raw</spirit:name>
                  <spirit:description>This register contains the registered state of interrupt signals</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>apb_tr_done</spirit:name>
                     <spirit:description>Current state of the APB SPI Flash transaction done flag (Active-High)</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>out_fifo_af</spirit:name>
                     <spirit:description>Current state of the output FIFO almost full flag (Active-High)</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>out_fifo_ae</spirit:name>
                     <spirit:description>Current state of the output FIFO almost empty flag (Active-High)</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_fifo_af</spirit:name>
                     <spirit:description>Current state of the input FIFO almost full flag (Active-High)</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>in_fifo_ae</spirit:name>
                     <spirit:description>Current state of the input FIFO almost empty flag (Active-High)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000944</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000938</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : irq  --> 
         <spirit:vendorExtensions>
               <ids_properties>
                  <module_name>spi_flash_ctrl_regs</module_name>
                  <uvm.package>spi_flash_ctrl_regs_pkg</uvm.package>
                  <reset_type>async</reset_type>
                  <cheader.mask_endianess>little</cheader.mask_endianess>
                  <header.struct_guard>__ASSEMBLER__</header.struct_guard>
                  <explicit_name>true</explicit_name>
                  <vertical_reuse>true</vertical_reuse>
                  <address>0x80000900</address>
               </ids_properties>
            </spirit:vendorExtensions>
         </spirit:addressBlock>     
         <spirit:addressBlock>     
            <spirit:name>gpio_ctrl</spirit:name>
            <spirit:description>GPIO Controller
</spirit:description>  <!-- //
                        block : gpio_ctrl  --> 
            <spirit:baseAddress>0x80000A00</spirit:baseAddress>               
            <spirit:range>0x100</spirit:range>               
            <spirit:width>32</spirit:width>            
            <spirit:register>
               <spirit:name>version</spirit:name>
               <spirit:description>Version</spirit:description>
               <spirit:addressOffset>0x0</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00030201</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>major</spirit:name>
                  <spirit:description>Major version</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000011</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>minor</spirit:name>
                  <spirit:description>Minor version</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000010</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>patch</spirit:name>
                  <spirit:description>Patch version</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000001</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000A00</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>gpio_dir</spirit:name>
               <spirit:description>GPIO Direction</spirit:description>
               <spirit:addressOffset>0x4</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>dir</spirit:name>
                  <spirit:description>GPIO Direction - one bit per GPIO
1'b0 : Input
1'b1 : Output</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>32</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000000000000000000000000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000A04</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>gpio_out</spirit:name>
               <spirit:description>GPIO Output</spirit:description>
               <spirit:addressOffset>0x8</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>out</spirit:name>
                  <spirit:description>GPIO Output - one bit per GPIO</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>32</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000000000000000000000000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000A08</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>gpio_in</spirit:name>
               <spirit:description>GPIO Input
</spirit:description>
               <spirit:addressOffset>0xC</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>in</spirit:name>
                  <spirit:description>GPIO Input - one bit per GPIO</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>32</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000000000000000000000000000</ids:default_value>
                     <ids_properties>
                        <registered>false</registered>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <registered>false</registered>
                     <address>0x80000A0C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>
  <!-- reg group
                    :irq  --> 
          <spirit:registerFile>
               <spirit:name>irq</spirit:name>
               <spirit:description>GPIO Controller Interrupt register group</spirit:description>
               <spirit:addressOffset>0x10</spirit:addressOffset>
               <spirit:range>0x20</spirit:range>            
               <spirit:register>
                  <spirit:name>enable</spirit:name>
                  <spirit:description>Interrupt Enable register - Write 1 to enable, 0 to mask an interrupt
</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>gpio31</spirit:name>
                     <spirit:description>Interrupt enable for GPIO31 input</spirit:description>
                     <spirit:bitOffset>31</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio30</spirit:name>
                     <spirit:description>Interrupt enable for GPIO30 input</spirit:description>
                     <spirit:bitOffset>30</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio29</spirit:name>
                     <spirit:description>Interrupt enable for GPIO29 input</spirit:description>
                     <spirit:bitOffset>29</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio28</spirit:name>
                     <spirit:description>Interrupt enable for GPIO28 input</spirit:description>
                     <spirit:bitOffset>28</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio27</spirit:name>
                     <spirit:description>Interrupt enable for GPIO27 input</spirit:description>
                     <spirit:bitOffset>27</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio26</spirit:name>
                     <spirit:description>Interrupt enable for GPIO26 input</spirit:description>
                     <spirit:bitOffset>26</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio25</spirit:name>
                     <spirit:description>Interrupt enable for GPIO25 input</spirit:description>
                     <spirit:bitOffset>25</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio24</spirit:name>
                     <spirit:description>Interrupt enable for GPIO24 input</spirit:description>
                     <spirit:bitOffset>24</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio23</spirit:name>
                     <spirit:description>Interrupt enable for GPIO23 input</spirit:description>
                     <spirit:bitOffset>23</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio22</spirit:name>
                     <spirit:description>Interrupt enable for GPIO22 input</spirit:description>
                     <spirit:bitOffset>22</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio21</spirit:name>
                     <spirit:description>Interrupt enable for GPIO21 input</spirit:description>
                     <spirit:bitOffset>21</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio20</spirit:name>
                     <spirit:description>Interrupt enable for GPIO20 input</spirit:description>
                     <spirit:bitOffset>20</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio19</spirit:name>
                     <spirit:description>Interrupt enable for GPIO19 input</spirit:description>
                     <spirit:bitOffset>19</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio18</spirit:name>
                     <spirit:description>Interrupt enable for GPIO18 input</spirit:description>
                     <spirit:bitOffset>18</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio17</spirit:name>
                     <spirit:description>Interrupt enable for GPIO17 input</spirit:description>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio16</spirit:name>
                     <spirit:description>Interrupt enable for GPIO16 input</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio15</spirit:name>
                     <spirit:description>Interrupt enable for GPIO15 input</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio14</spirit:name>
                     <spirit:description>Interrupt enable for GPIO14 input</spirit:description>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio13</spirit:name>
                     <spirit:description>Interrupt enable for GPIO13 input</spirit:description>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio12</spirit:name>
                     <spirit:description>Interrupt enable for GPIO12 input</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio11</spirit:name>
                     <spirit:description>Interrupt enable for GPIO11 input</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio10</spirit:name>
                     <spirit:description>Interrupt enable for GPIO10 input</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio9</spirit:name>
                     <spirit:description>Interrupt enable for GPIO9 input</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio8</spirit:name>
                     <spirit:description>Interrupt enable for GPIO8 input</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio7</spirit:name>
                     <spirit:description>Interrupt enable for GPIO7 input</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio6</spirit:name>
                     <spirit:description>Interrupt enable for GPIO6 input</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio5</spirit:name>
                     <spirit:description>Interrupt enable for GPIO5 input</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio4</spirit:name>
                     <spirit:description>Interrupt enable for GPIO4 input</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio3</spirit:name>
                     <spirit:description>Interrupt enable for GPIO3 input</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio2</spirit:name>
                     <spirit:description>Interrupt enable for GPIO2 input</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio1</spirit:name>
                     <spirit:description>Interrupt enable for GPIO1 input</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio0</spirit:name>
                     <spirit:description>Interrupt enable for GPIO0 input</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000A10</address>
                        <intr.enable>irq0_gpio_ctrl</intr.enable>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending</spirit:name>
                  <spirit:description>Pending register - This indicates which GPIO inputs are pending, Write 1 to clear
</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>gpio31</spirit:name>
                     <spirit:description>Pending for GPIO31 input</spirit:description>
                     <spirit:bitOffset>31</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio30</spirit:name>
                     <spirit:description>Pending for GPIO30 input</spirit:description>
                     <spirit:bitOffset>30</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio29</spirit:name>
                     <spirit:description>Pending for GPIO29 input</spirit:description>
                     <spirit:bitOffset>29</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio28</spirit:name>
                     <spirit:description>Pending for GPIO28 input</spirit:description>
                     <spirit:bitOffset>28</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio27</spirit:name>
                     <spirit:description>Pending for GPIO27 input</spirit:description>
                     <spirit:bitOffset>27</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio26</spirit:name>
                     <spirit:description>Pending for GPIO26 input</spirit:description>
                     <spirit:bitOffset>26</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio25</spirit:name>
                     <spirit:description>Pending for GPIO25 input</spirit:description>
                     <spirit:bitOffset>25</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio24</spirit:name>
                     <spirit:description>Pending for GPIO24 input</spirit:description>
                     <spirit:bitOffset>24</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio23</spirit:name>
                     <spirit:description>Pending for GPIO23 input</spirit:description>
                     <spirit:bitOffset>23</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio22</spirit:name>
                     <spirit:description>Pending for GPIO22 input</spirit:description>
                     <spirit:bitOffset>22</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio21</spirit:name>
                     <spirit:description>Pending for GPIO21 input</spirit:description>
                     <spirit:bitOffset>21</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio20</spirit:name>
                     <spirit:description>Pending for GPIO20 input</spirit:description>
                     <spirit:bitOffset>20</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio19</spirit:name>
                     <spirit:description>Pending for GPIO19 input</spirit:description>
                     <spirit:bitOffset>19</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio18</spirit:name>
                     <spirit:description>Pending for GPIO18 input</spirit:description>
                     <spirit:bitOffset>18</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio17</spirit:name>
                     <spirit:description>Pending for GPIO17 input</spirit:description>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio16</spirit:name>
                     <spirit:description>Pending for GPIO16 input</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio15</spirit:name>
                     <spirit:description>Pending for GPIO15 input</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio14</spirit:name>
                     <spirit:description>Pending for GPIO14 input</spirit:description>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio13</spirit:name>
                     <spirit:description>Pending for GPIO13 input</spirit:description>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio12</spirit:name>
                     <spirit:description>Pending for GPIO12 input</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio11</spirit:name>
                     <spirit:description>Pending for GPIO11 input</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio10</spirit:name>
                     <spirit:description>Pending for GPIO10 input</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio9</spirit:name>
                     <spirit:description>Pending for GPIO9 input</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio8</spirit:name>
                     <spirit:description>Pending for GPIO8 input</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio7</spirit:name>
                     <spirit:description>Pending for GPIO7 input</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio6</spirit:name>
                     <spirit:description>Pending for GPIO6 input</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio5</spirit:name>
                     <spirit:description>Pending for GPIO5 input</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio4</spirit:name>
                     <spirit:description>Pending for GPIO4 input</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio3</spirit:name>
                     <spirit:description>Pending for GPIO3 input</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio2</spirit:name>
                     <spirit:description>Pending for GPIO2 input</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio1</spirit:name>
                     <spirit:description>Pending for GPIO1 input</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio0</spirit:name>
                     <spirit:description>Pending for GPIO0 input</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000A14</address>
                        <intr.status>irq0_gpio_ctrl</intr.status>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending_irq</spirit:name>
                  <spirit:description>Interrupt Pending register - This indicates which pending GPIO inputs are enabled to cause an interrupt
</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>gpio31</spirit:name>
                     <spirit:description>Interrupt pending for GPIO31 input</spirit:description>
                     <spirit:bitOffset>31</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio30</spirit:name>
                     <spirit:description>Interrupt pending for GPIO30 input</spirit:description>
                     <spirit:bitOffset>30</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio29</spirit:name>
                     <spirit:description>Interrupt pending for GPIO29 input</spirit:description>
                     <spirit:bitOffset>29</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio28</spirit:name>
                     <spirit:description>Interrupt pending for GPIO28 input</spirit:description>
                     <spirit:bitOffset>28</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio27</spirit:name>
                     <spirit:description>Interrupt pending for GPIO27 input</spirit:description>
                     <spirit:bitOffset>27</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio26</spirit:name>
                     <spirit:description>Interrupt pending for GPIO26 input</spirit:description>
                     <spirit:bitOffset>26</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio25</spirit:name>
                     <spirit:description>Interrupt pending for GPIO25 input</spirit:description>
                     <spirit:bitOffset>25</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio24</spirit:name>
                     <spirit:description>Interrupt pending for GPIO24 input</spirit:description>
                     <spirit:bitOffset>24</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio23</spirit:name>
                     <spirit:description>Interrupt pending for GPIO23 input</spirit:description>
                     <spirit:bitOffset>23</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio22</spirit:name>
                     <spirit:description>Interrupt pending for GPIO22 input</spirit:description>
                     <spirit:bitOffset>22</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio21</spirit:name>
                     <spirit:description>Interrupt pending for GPIO21 input</spirit:description>
                     <spirit:bitOffset>21</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio20</spirit:name>
                     <spirit:description>Interrupt pending for GPIO20 input</spirit:description>
                     <spirit:bitOffset>20</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio19</spirit:name>
                     <spirit:description>Interrupt pending for GPIO19 input</spirit:description>
                     <spirit:bitOffset>19</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio18</spirit:name>
                     <spirit:description>Interrupt pending for GPIO18 input</spirit:description>
                     <spirit:bitOffset>18</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio17</spirit:name>
                     <spirit:description>Interrupt pending for GPIO17 input</spirit:description>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio16</spirit:name>
                     <spirit:description>Interrupt pending for GPIO16 input</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio15</spirit:name>
                     <spirit:description>Interrupt pending for GPIO15 input</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio14</spirit:name>
                     <spirit:description>Interrupt pending for GPIO14 input</spirit:description>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio13</spirit:name>
                     <spirit:description>Interrupt pending for GPIO13 input</spirit:description>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio12</spirit:name>
                     <spirit:description>Interrupt pending for GPIO12 input</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio11</spirit:name>
                     <spirit:description>Interrupt pending for GPIO11 input</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio10</spirit:name>
                     <spirit:description>Interrupt pending for GPIO10 input</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio9</spirit:name>
                     <spirit:description>Interrupt pending for GPIO9 input</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio8</spirit:name>
                     <spirit:description>Interrupt pending for GPIO8 input</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio7</spirit:name>
                     <spirit:description>Interrupt pending for GPIO7 input</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio6</spirit:name>
                     <spirit:description>Interrupt pending for GPIO6 input</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio5</spirit:name>
                     <spirit:description>Interrupt pending for GPIO5 input</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio4</spirit:name>
                     <spirit:description>Interrupt pending for GPIO4 input</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio3</spirit:name>
                     <spirit:description>Interrupt pending for GPIO3 input</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio2</spirit:name>
                     <spirit:description>Interrupt pending for GPIO2 input</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio1</spirit:name>
                     <spirit:description>Interrupt pending for GPIO1 input</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio0</spirit:name>
                     <spirit:description>Interrupt pending for GPIO0 input</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000A18</address>
                        <intr.pending>irq0_gpio_ctrl</intr.pending>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>raw</spirit:name>
                  <spirit:description>This register contains the registered state of interrupt signals
</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>gpio31</spirit:name>
                     <spirit:description>Current state for GPIO31 input</spirit:description>
                     <spirit:bitOffset>31</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <registered>false</registered>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio30</spirit:name>
                     <spirit:description>Current state for GPIO30 input</spirit:description>
                     <spirit:bitOffset>30</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <registered>false</registered>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio29</spirit:name>
                     <spirit:description>Current state for GPIO29 input</spirit:description>
                     <spirit:bitOffset>29</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <registered>false</registered>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio28</spirit:name>
                     <spirit:description>Current state for GPIO28 input</spirit:description>
                     <spirit:bitOffset>28</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <registered>false</registered>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio27</spirit:name>
                     <spirit:description>Current state for GPIO27 input</spirit:description>
                     <spirit:bitOffset>27</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <registered>false</registered>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio26</spirit:name>
                     <spirit:description>Current state for GPIO26 input</spirit:description>
                     <spirit:bitOffset>26</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <registered>false</registered>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio25</spirit:name>
                     <spirit:description>Current state for GPIO25 input</spirit:description>
                     <spirit:bitOffset>25</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <registered>false</registered>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio24</spirit:name>
                     <spirit:description>Current state for GPIO24 input</spirit:description>
                     <spirit:bitOffset>24</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <registered>false</registered>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio23</spirit:name>
                     <spirit:description>Current state for GPIO23 input</spirit:description>
                     <spirit:bitOffset>23</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <registered>false</registered>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio22</spirit:name>
                     <spirit:description>Current state for GPIO22 input</spirit:description>
                     <spirit:bitOffset>22</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <registered>false</registered>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio21</spirit:name>
                     <spirit:description>Current state for GPIO21 input</spirit:description>
                     <spirit:bitOffset>21</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <registered>false</registered>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio20</spirit:name>
                     <spirit:description>Current state for GPIO20 input</spirit:description>
                     <spirit:bitOffset>20</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <registered>false</registered>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio19</spirit:name>
                     <spirit:description>Current state for GPIO19 input</spirit:description>
                     <spirit:bitOffset>19</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <registered>false</registered>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio18</spirit:name>
                     <spirit:description>Current state for GPIO18 input</spirit:description>
                     <spirit:bitOffset>18</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <registered>false</registered>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio17</spirit:name>
                     <spirit:description>Current state for GPIO17 input</spirit:description>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <registered>false</registered>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio16</spirit:name>
                     <spirit:description>Current state for GPIO16 input</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <registered>false</registered>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio15</spirit:name>
                     <spirit:description>Current state for GPIO15 input</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <registered>false</registered>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio14</spirit:name>
                     <spirit:description>Current state for GPIO14 input</spirit:description>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <registered>false</registered>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio13</spirit:name>
                     <spirit:description>Current state for GPIO13 input</spirit:description>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <registered>false</registered>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio12</spirit:name>
                     <spirit:description>Current state for GPIO12 input</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <registered>false</registered>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio11</spirit:name>
                     <spirit:description>Current state for GPIO11 input</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <registered>false</registered>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio10</spirit:name>
                     <spirit:description>Current state for GPIO10 input</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <registered>false</registered>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio9</spirit:name>
                     <spirit:description>Current state for GPIO9 input</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <registered>false</registered>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio8</spirit:name>
                     <spirit:description>Current state for GPIO8 input</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <registered>false</registered>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio7</spirit:name>
                     <spirit:description>Current state for GPIO7 input</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <registered>false</registered>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio6</spirit:name>
                     <spirit:description>Current state for GPIO6 input</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <registered>false</registered>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio5</spirit:name>
                     <spirit:description>Current state for GPIO5 input</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <registered>false</registered>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio4</spirit:name>
                     <spirit:description>Current state for GPIO4 input</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <registered>false</registered>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio3</spirit:name>
                     <spirit:description>Current state for GPIO3 input</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <registered>false</registered>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio2</spirit:name>
                     <spirit:description>Current state for GPIO2 input</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <registered>false</registered>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio1</spirit:name>
                     <spirit:description>Current state for GPIO1 input</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <registered>false</registered>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio0</spirit:name>
                     <spirit:description>Current state for GPIO0 input</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <registered>false</registered>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <registered>false</registered>
                        <address>0x80000A1C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>int_type</spirit:name>
                  <spirit:description>This register contains the interrupt type per GPIO
</spirit:description>
                  <spirit:dim>4</spirit:dim>
                  <spirit:addressOffset>0x10</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>gpio7</spirit:name>
                     <spirit:description>Interrupt Type
0 : Rising Edge
1 : Falling Edge
2 : Rising or Falling Edge
3 : High Level
4 : Low Level
5-15 : Reserved</spirit:description>
                     <spirit:bitOffset>28</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio6</spirit:name>
                     <spirit:description>Interrupt Type
0 : Rising Edge
1 : Falling Edge
2 : Rising or Falling Edge
3 : High Level
4 : Low Level
5-15 : Reserved</spirit:description>
                     <spirit:bitOffset>24</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio5</spirit:name>
                     <spirit:description>Interrupt Type
0 : Rising Edge
1 : Falling Edge
2 : Rising or Falling Edge
3 : High Level
4 : Low Level
5-15 : Reserved</spirit:description>
                     <spirit:bitOffset>20</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio4</spirit:name>
                     <spirit:description>Interrupt Type
0 : Rising Edge
1 : Falling Edge
2 : Rising or Falling Edge
3 : High Level
4 : Low Level
5-15 : Reserved</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio3</spirit:name>
                     <spirit:description>Interrupt Type
0 : Rising Edge
1 : Falling Edge
2 : Rising or Falling Edge
3 : High Level
4 : Low Level
5-15 : Reserved</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio2</spirit:name>
                     <spirit:description>Interrupt Type
0 : Rising Edge
1 : Falling Edge
2 : Rising or Falling Edge
3 : High Level
4 : Low Level
5-15 : Reserved</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio1</spirit:name>
                     <spirit:description>Interrupt Type
0 : Rising Edge
1 : Falling Edge
2 : Rising or Falling Edge
3 : High Level
4 : Low Level
5-15 : Reserved</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio0</spirit:name>
                     <spirit:description>Interrupt Type
0 : Rising Edge
1 : Falling Edge
2 : Rising or Falling Edge
3 : High Level
4 : Low Level
5-15 : Reserved</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80000A20</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80000A10</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : irq  --> 
         <spirit:vendorExtensions>
               <ids_properties>
                  <module_name>gpio_ctrl_regs</module_name>
                  <uvm.package>gpio_ctrl_regs_pkg</uvm.package>
                  <reset_type>async</reset_type>
                  <cheader.mask_endianess>little</cheader.mask_endianess>
                  <header.struct_guard>__ASSEMBLER__</header.struct_guard>
                  <explicit_name>true</explicit_name>
                  <vertical_reuse>true</vertical_reuse>
                  <address>0x80000A00</address>
               </ids_properties>
            </spirit:vendorExtensions>
         </spirit:addressBlock>     
         <spirit:addressBlock>     
            <spirit:name>bb_core</spirit:name>
            <spirit:description>BlackBird Core Registers
</spirit:description>  <!-- //
                        block : bb_core  --> 
            <spirit:baseAddress>0x80001000</spirit:baseAddress>               
            <spirit:range>0x100</spirit:range>               
            <spirit:width>32</spirit:width>            
            <spirit:register>
               <spirit:name>version</spirit:name>
               <spirit:description>Version</spirit:description>
               <spirit:addressOffset>0x0</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:reset>
                  <spirit:value>0x000C0701</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>major</spirit:name>
                  <spirit:description>Major version</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00001100</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>minor</spirit:name>
                  <spirit:description>Minor version</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000111</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>patch</spirit:name>
                  <spirit:description>Patch version</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000001</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80001000</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>cpu_freq</spirit:name>
               <spirit:description>CPU Frequency</spirit:description>
               <spirit:addressOffset>0x4</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>value</spirit:name>
                  <spirit:description>CPU frequency in Hz</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>32</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000000000000000000000000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80001004</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>sys_config</spirit:name>
               <spirit:description>System configuration</spirit:description>
               <spirit:addressOffset>0x8</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>link_rate</spirit:name>
                  <spirit:description>Link Rate</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>4</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>link_mode</spirit:name>
                  <spirit:description>Link Mode</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>5</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>boot_sel</spirit:name>
                  <spirit:description>Boot Select
0 : Program Mode
1 : Boot from Flash
2 : Boot from I2C Slave
3 : Boot from IRAM</spirit:description>
                  <spirit:bitOffset>4</spirit:bitOffset>
                  <spirit:bitWidth>2</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>rex_lex_n</spirit:name>
                  <spirit:description>Extender Select
0 : Local (LEX)
1 : Remote (REX)</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80001008</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>feature</spirit:name>
               <spirit:description>Features present</spirit:description>
               <spirit:addressOffset>0xC</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>xgmii_rx_idle_counter</spirit:name>
                  <spirit:description>XGMII RX Idle Counter present</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>rs232_extender</spirit:name>
                  <spirit:description>RS-232 Extender present</spirit:description>
                  <spirit:bitOffset>15</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>ge_uart</spirit:name>
                  <spirit:description>GE UART present</spirit:description>
                  <spirit:bitOffset>14</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>ge_adapter</spirit:name>
                  <spirit:description>GE Adapter present</spirit:description>
                  <spirit:bitOffset>13</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>xmii_adapter</spirit:name>
                  <spirit:description>XMII Adapter present</spirit:description>
                  <spirit:bitOffset>12</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>dp_source</spirit:name>
                  <spirit:description>DisplayPort Source present</spirit:description>
                  <spirit:bitOffset>11</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>dp_sink</spirit:name>
                  <spirit:description>DisplayPort Sink present</spirit:description>
                  <spirit:bitOffset>10</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>xusb3</spirit:name>
                  <spirit:description>XUSB3 present</spirit:description>
                  <spirit:bitOffset>9</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>mca</spirit:name>
                  <spirit:description>MCA present</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>layer3</spirit:name>
                  <spirit:description>Layer 3 present</spirit:description>
                  <spirit:bitOffset>7</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>link_layer</spirit:name>
                  <spirit:description>Data Link Layer present</spirit:description>
                  <spirit:bitOffset>6</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>gpio_ctrl</spirit:name>
                  <spirit:description>GPIO controller present</spirit:description>
                  <spirit:bitOffset>5</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>spi_flash_ctrl</spirit:name>
                  <spirit:description>SPI Flash Controller present</spirit:description>
                  <spirit:bitOffset>4</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>mdio_master</spirit:name>
                  <spirit:description>MDIO Master present</spirit:description>
                  <spirit:bitOffset>3</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>i2c_slave</spirit:name>
                  <spirit:description>I2C Slave present</spirit:description>
                  <spirit:bitOffset>2</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>i2c_master</spirit:name>
                  <spirit:description>I2C Master present</spirit:description>
                  <spirit:bitOffset>1</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>bb_uart</spirit:name>
                  <spirit:description>BB UART present</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x8000100C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>module_version_ctrl</spirit:name>
               <spirit:description>Module version control</spirit:description>
               <spirit:addressOffset>0x10</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>version_sel</spirit:name>
                  <spirit:description>Version select
- Use this for modules that have more than one version</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>module_sel</spirit:name>
                  <spirit:description>Module select
- To read a version of a particular module, set this field to the index of the module in the feature register
- If a module has more than one version, use the version_sel field to select the one of interest
- Once the right module is selected and where applicable the right version within the module, issue a read of the module_version register to obtain the version of interest
- Note that a module must be present to be able to read its version
- Note that some modules do not have a register interface and as a result do not have a version</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80001010</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>module_version</spirit:name>
               <spirit:description>Module version</spirit:description>
               <spirit:addressOffset>0x14</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>major</spirit:name>
                  <spirit:description>Module major version</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>minor</spirit:name>
                  <spirit:description>Module minor version</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>patch</spirit:name>
                  <spirit:description>Module patch version</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80001014</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>
  <!-- reg group
                    :irq  --> 
          <spirit:registerFile>
               <spirit:name>irq</spirit:name>
               <spirit:description>BlackBird Core Interrupt register group</spirit:description>
               <spirit:addressOffset>0x18</spirit:addressOffset>
               <spirit:range>0x10</spirit:range>            
               <spirit:register>
                  <spirit:name>enable</spirit:name>
                  <spirit:description>Interrupt Enable register - Write 1 to enable, 0 to mask an interrupt
</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>rs232_underrun_err</spirit:name>
                     <spirit:description>RS-232 Underrun Error Interrupt</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mca_rx_cpu_srdy</spirit:name>
                     <spirit:description>MCA RX CPU SRDY Interrupt</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80001018</address>
                        <intr.enable>irq0_bb_core</intr.enable>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending</spirit:name>
                  <spirit:description>Pending register - This indicates which events are pending, Write 1 to clear
</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>rs232_underrun_err</spirit:name>
                     <spirit:description>Edge-triggered - Active-High
RS-232 Underrun Error</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mca_rx_cpu_srdy</spirit:name>
                     <spirit:description>Level-triggered - Active-High
MCA RX CPU SRDY</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000101C</address>
                        <intr.status>irq0_bb_core</intr.status>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending_irq</spirit:name>
                  <spirit:description>Interrupt Pending register - This indicates which pending events are enabled to cause an interrupt
</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>rs232_underrun_err</spirit:name>
                     <spirit:description>Edge-triggered - Active-High
RS-232 Underrun Error</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mca_rx_cpu_srdy</spirit:name>
                     <spirit:description>Level-triggered - Active-High
MCA RX CPU SRDY</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80001020</address>
                        <intr.pending>irq0_bb_core</intr.pending>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>raw</spirit:name>
                  <spirit:description>This register contains the registered state of interrupt signals</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>rs232_underrun_err</spirit:name>
                     <spirit:description>Current state of the RS-232 Underrun Error (Active-High)</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mca_rx_cpu_srdy</spirit:name>
                     <spirit:description>Current state of the MCA RX CPU SRDY (Active-High)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80001024</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80001018</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : irq  --> 
            <spirit:register>
               <spirit:name>cpu_comm_tx</spirit:name>
               <spirit:description>CPU Communication TX Control</spirit:description>
               <spirit:addressOffset>0x28</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>eop</spirit:name>
                  <spirit:description>End-Of-Packet (Active-High)
Indicates whether this is the last byte of a packet</spirit:description>
                  <spirit:bitOffset>9</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>sop</spirit:name>
                  <spirit:description>Start-Of-Packet (Active-High)
Indicates whether this is the first byte of a packet</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>data</spirit:name>
                  <spirit:description>Byte to write into the communication channel
</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                     <ids_properties>
                        <rtl.hw_wp>1</rtl.hw_wp>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80001028</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>cpu_comm_rx</spirit:name>
               <spirit:description>CPU Communication RX Status</spirit:description>
               <spirit:addressOffset>0x2C</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>eop</spirit:name>
                  <spirit:description>End-Of-Packet (Active-High)
Indicates whether this is the last byte of a packet</spirit:description>
                  <spirit:bitOffset>9</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>sop</spirit:name>
                  <spirit:description>Start-Of-Packet (Active-High)
Indicates whether this is the first byte of a packet</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>data</spirit:name>
                  <spirit:description>Byte read from the communication channel
</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                     <ids_properties>
                        <rtl.hw_rp>1</rtl.hw_rp>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x8000102C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>xmii_ctrl</spirit:name>
               <spirit:description>XMII control</spirit:description>
               <spirit:addressOffset>0x30</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000B00</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>ipg_m1</spirit:name>
                  <spirit:description>Inter Packet Gap - 1 (minimum number of clock cycles between packets, e.g to guarantee 12 set this to 11)</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00001011</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>mode</spirit:name>
                  <spirit:description>XMII Mode:
0 : GMII
1 : MII
2 : RGMII
3 : RMII</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>2</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80001030</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>rs232_ctrl</spirit:name>
               <spirit:description>RS-232 control</spirit:description>
               <spirit:addressOffset>0x34</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00010000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>clk_down_scale</spirit:name>
                  <spirit:description>Module Clock Down Scaling Factor
Scale the module clock to a minimum of 16x the baud rate:
floor(&lt;freq&gt;/(16x&lt;baud rate&gt;))</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>16</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0000000000000001</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>enable</spirit:name>
                  <spirit:description>Enable (Active-High)</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80001034</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>
  <!-- reg group
                    :xgmii_idle_counter  --> 
          <spirit:registerFile>
               <spirit:name>xgmii_idle_counter</spirit:name>
               <spirit:description>XGMII Idle Counter</spirit:description>
               <spirit:addressOffset>0x38</spirit:addressOffset>
               <spirit:range>0x8</spirit:range>            
               <spirit:register>
                  <spirit:name>control</spirit:name>
                  <spirit:description>Control register</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x0001FFFE</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>num_xgmii_clks</spirit:name>
                     <spirit:description>Number of XGMII clocks to do the XGMII idle count</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>31</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000001111111111111111</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>go</spirit:name>
                     <spirit:description>Write a 1 to initiate a XGMII idle count. HW will clear this field upon completion. Once cleared the number of idles can be obtained.
</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <rtl.hw_clear>1</rtl.hw_clear>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80001038</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>status</spirit:name>
                  <spirit:description>Status register</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>idle_count</spirit:name>
                     <spirit:description>Number of XGMII idles counted</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>32</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000000000000000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000103C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80001038</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : xgmii_idle_counter  --> 
            <spirit:register>
               <spirit:name>ahb_to_apb_ctrl</spirit:name>
               <spirit:description>AHB to APB Bridge control</spirit:description>
               <spirit:addressOffset>0x40</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>timeout_hresp</spirit:name>
                  <spirit:description>HRESP on timeout
0 : OKAY
1 : ERROR</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80001040</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>ge_ctrl</spirit:name>
               <spirit:description>GoldenEars control</spirit:description>
               <spirit:addressOffset>0x44</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>clei_tx</spirit:name>
                  <spirit:description>0 : PTP to GMII
1 : PTP to CLEI</spirit:description>
                  <spirit:bitOffset>1</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>clei_rx</spirit:name>
                  <spirit:description>0 : GMII to PTP
1 : CLEI to PTP (with flow control)</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80001044</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>
  <!-- reg group
                    :scratchpad  --> 
          <spirit:registerFile>
               <spirit:name>scratchpad</spirit:name>
               <spirit:description>Scratchpad Register Group</spirit:description>
               <spirit:addressOffset>0x48</spirit:addressOffset>
               <spirit:range>0x10</spirit:range>            
               <spirit:register>
                  <spirit:name>spr</spirit:name>
                  <spirit:description>Scratchpad Register
</spirit:description>
                  <spirit:dim>4</spirit:dim>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>value</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>32</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000000000000000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80001048</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80001048</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : scratchpad  --> 
         <spirit:vendorExtensions>
               <ids_properties>
                  <module_name>bb_core_regs</module_name>
                  <uvm.package>bb_core_regs_pkg</uvm.package>
                  <reset_type>async</reset_type>
                  <cheader.mask_endianess>little</cheader.mask_endianess>
                  <header.struct_guard>__ASSEMBLER__</header.struct_guard>
                  <explicit_name>true</explicit_name>
                  <vertical_reuse>true</vertical_reuse>
                  <address>0x80001000</address>
               </ids_properties>
            </spirit:vendorExtensions>
         </spirit:addressBlock>     
         <spirit:addressBlock>     
            <spirit:name>bb_top</spirit:name>
            <spirit:description>BlackBird Global Registers for A7 Core
</spirit:description>  <!-- //
                        block : bb_top  --> 
            <spirit:baseAddress>0x80002000</spirit:baseAddress>               
            <spirit:range>0x200</spirit:range>               
            <spirit:width>32</spirit:width>            
            <spirit:register>
               <spirit:name>version</spirit:name>
               <spirit:description>Version</spirit:description>
               <spirit:addressOffset>0x0</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:reset>
                  <spirit:value>0x00100104</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>major</spirit:name>
                  <spirit:description>Major version</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00010000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>minor</spirit:name>
                  <spirit:description>Minor version</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000001</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>patch</spirit:name>
                  <spirit:description>Patch version</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000100</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80002000</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>sys_config</spirit:name>
               <spirit:description>System configuration</spirit:description>
               <spirit:addressOffset>0x4</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>env_info</spirit:name>
                  <spirit:description>Environment Information - See tech register spreadsheet for details</spirit:description>
                  <spirit:bitOffset>24</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>platform_support</spirit:name>
                  <spirit:description>FPGA Platform Support - See tech register spreadsheet for details</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>base_platform</spirit:name>
                  <spirit:description>FPGA Base Platform - See tech register spreadsheet for details</spirit:description>
                  <spirit:bitOffset>10</spirit:bitOffset>
                  <spirit:bitWidth>4</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>image_type</spirit:name>
                  <spirit:description>FPGA Image Type - See tech register spreadsheet for details</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>2</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>part_number</spirit:name>
                  <spirit:description>Part Number - See tech register spreadsheet for details</spirit:description>
                  <spirit:bitOffset>4</spirit:bitOffset>
                  <spirit:bitWidth>4</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>vendor</spirit:name>
                  <spirit:description>Vendor Information - See tech register spreadsheet for details</spirit:description>
                  <spirit:bitOffset>2</spirit:bitOffset>
                  <spirit:bitWidth>2</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>technology</spirit:name>
                  <spirit:description>Technology - See tech register spreadsheet for details</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80002004</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>feature</spirit:name>
               <spirit:description>Features present</spirit:description>
               <spirit:addressOffset>0x8</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>dp_gtp</spirit:name>
                  <spirit:description>DisplayPort transceivers present</spirit:description>
                  <spirit:bitOffset>4</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>xadc</spirit:name>
                  <spirit:description>XADC present</spirit:description>
                  <spirit:bitOffset>3</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>sl_5g</spirit:name>
                  <spirit:description>Single Lane 5G present</spirit:description>
                  <spirit:bitOffset>2</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>rxaui_l0_t1</spirit:name>
                  <spirit:description>RXAUI with lane 0 mapped to transceiver 1 present</spirit:description>
                  <spirit:bitOffset>1</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>rxaui_l0_t0</spirit:name>
                  <spirit:description>RXAUI with lane 0 mapped to transceiver 0 present</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80002008</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>
  <!-- reg group
                    :icap  --> 
          <spirit:registerFile>
               <spirit:name>icap</spirit:name>
               <spirit:description>ICAP register group</spirit:description>
               <spirit:addressOffset>0xC</spirit:addressOffset>
               <spirit:range>0x8</spirit:range>            
               <spirit:register>
                  <spirit:name>wdata</spirit:name>
                  <spirit:description>Write Data</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>val</spirit:name>
                     <spirit:description>ICAP Write Data
</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>32</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        <ids_properties>
                           <rtl.hw_wp>1</rtl.hw_wp>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000200C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>rdata</spirit:name>
                  <spirit:description>Read Data</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>val</spirit:name>
                     <spirit:description>ICAP Read Data
</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>32</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        <ids_properties>
                           <rtl.hw_wp>1</rtl.hw_wp>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80002010</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x8000200C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : icap  --> 

  <!-- reg group
                    :grm  --> 
          <spirit:registerFile>
               <spirit:name>grm</spirit:name>
               <spirit:description>Global Register Module registers group</spirit:description>
               <spirit:addressOffset>0x14</spirit:addressOffset>
               <spirit:range>0x4</spirit:range>            
               <spirit:register>
                  <spirit:name>soft_rst_ctrl</spirit:name>
                  <spirit:description>Soft Module Reset Control register</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x3FFFFFFF</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>cpu_rst</spirit:name>
                     <spirit:description>CPU Reset (Active-High)</spirit:description>
                     <spirit:bitOffset>31</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>link_stats_rx_rst</spirit:name>
                     <spirit:description>Link Stats RX Reset (Active-High)</spirit:description>
                     <spirit:bitOffset>29</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sl_5g_rx_rst</spirit:name>
                     <spirit:description>SL 5G RX Reset (Active-High)</spirit:description>
                     <spirit:bitOffset>28</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sl_5g_tx_rst</spirit:name>
                     <spirit:description>SL 5G TX Reset (Active-High)</spirit:description>
                     <spirit:bitOffset>27</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>xmii_rx_rst</spirit:name>
                     <spirit:description>XMII RX Reset (Active-High)</spirit:description>
                     <spirit:bitOffset>26</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>xmii_tx_rst</spirit:name>
                     <spirit:description>XMII TX Reset (Active-High)</spirit:description>
                     <spirit:bitOffset>25</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ge_clm_rx_rst</spirit:name>
                     <spirit:description>GE CLM RX Reset (Active-High)</spirit:description>
                     <spirit:bitOffset>24</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ge_clm_tx_rst</spirit:name>
                     <spirit:description>GE CLM TX Reset (Active-High)</spirit:description>
                     <spirit:bitOffset>23</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rs232_rst</spirit:name>
                     <spirit:description>RS-232 Reset (Active-High)</spirit:description>
                     <spirit:bitOffset>22</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ulp_phy_rst</spirit:name>
                     <spirit:description>ULP PHY Reset (Active-High)</spirit:description>
                     <spirit:bitOffset>21</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ulp_core_rst</spirit:name>
                     <spirit:description>ULP Core Reset (Active-High)</spirit:description>
                     <spirit:bitOffset>20</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>upp_rst</spirit:name>
                     <spirit:description>UPP Reset (Active-High)</spirit:description>
                     <spirit:bitOffset>19</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>xusb_rst</spirit:name>
                     <spirit:description>XUSB Reset (Active-High)</spirit:description>
                     <spirit:bitOffset>18</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tico_d_ctrl_rst</spirit:name>
                     <spirit:description>TICO Decoder Control Reset (Active-High)</spirit:description>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_source_rst</spirit:name>
                     <spirit:description>DisplayPort Source Reset (Active-High)</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tico_e_ctrl_rst</spirit:name>
                     <spirit:description>TICO Encoder Control Reset (Active-High)</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_sink_rst</spirit:name>
                     <spirit:description>DisplayPort Sink Reset (Active-High)</spirit:description>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_aux_hpd_rst</spirit:name>
                     <spirit:description>DisplayPort AUX and HPD Reset (Active-High)</spirit:description>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mca_core_rx_rst</spirit:name>
                     <spirit:description>MCA Core RX Reset (Active-High)</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mca_core_tx_rst</spirit:name>
                     <spirit:description>MCA Core TX Reset (Active-High)</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>l3_rx_rst</spirit:name>
                     <spirit:description>Layer 3 RX Reset (Active-High)</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>l3_tx_rst</spirit:name>
                     <spirit:description>Layer 3 TX Reset (Active-High)</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dll_rx_rst</spirit:name>
                     <spirit:description>Data Link Layer RX Reset (Active-High)</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dll_tx_rst</spirit:name>
                     <spirit:description>Data Link Layer TX Reset (Active-High)</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gpio_ctrl_rst</spirit:name>
                     <spirit:description>GPIO Controller Reset (Active-High)</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>spi_flash_ctrl_rst</spirit:name>
                     <spirit:description>SPI Flash Controller Reset (Active-High)</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mdio_master_rst</spirit:name>
                     <spirit:description>MDIO Master Reset (Active-High)</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>i2c_slave_rst</spirit:name>
                     <spirit:description>I2C Slave Reset (Active-High)</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>i2c_master_rst</spirit:name>
                     <spirit:description>I2C Master Reset (Active-High)</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ge_uart_rst</spirit:name>
                     <spirit:description>GoldenEars UART Reset (Active-High)</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>bb_uart_rst</spirit:name>
                     <spirit:description>BlackBird UART Reset (Active-High)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80002014</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80002014</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : grm  --> 

  <!-- reg group
                    :gcm  --> 
          <spirit:registerFile>
               <spirit:name>gcm</spirit:name>
               <spirit:description>Global Clock Module register group</spirit:description>
               <spirit:addressOffset>0x18</spirit:addressOffset>
               <spirit:range>0x14</spirit:range>            
               <spirit:register>
                  <spirit:name>control</spirit:name>
                  <spirit:description>GCM Control register</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000101</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>link_gt_common_pll0reset</spirit:name>
                     <spirit:description>Link GTPE2 COMMON PLL0RESET (Active-High) (See UG482, Table 2-8)</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>xmii_tx_clk_sel</spirit:name>
                     <spirit:description>XMII TX CLK Select:
0 : GMII Reference Clock
1 : TX_CLK</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ulp_phy_clk_pll_rst</spirit:name>
                     <spirit:description>ULP PHY Clock PLL Reset (Active-High)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80002018</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>status</spirit:name>
                  <spirit:description>GCM Status register</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>link_mmcm_lock</spirit:name>
                     <spirit:description>Link MMCM (Active-High)</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>link_gt_common_pll0refclklost</spirit:name>
                     <spirit:description>Link GTPE2 COMMON PLL0REFCLKLOST (Active-High) (See UG482, Table 2-8)</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>link_gt_common_pll0lock</spirit:name>
                     <spirit:description>Link GTPE2 COMMON PLL0LOCK (Active-High) (See UG482, Table 2-8)</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ulp_phy_clk_lock</spirit:name>
                     <spirit:description>ULP PHY Clock PLL Lock (Active-High)</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>cpu_clk_lock</spirit:name>
                     <spirit:description>CPU Clock MMCM Lock (Active-High)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000201C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>freq_det</spirit:name>
                  <spirit:description>Frequency Detect register</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>count</spirit:name>
                     <spirit:description>Count value used for frequency calculation:
 if (ref_clk_faster)
    freq_min(det_clk) = freq(ref_clk)*((count+2)/(max_count+1))
    freq_max(det_clk) = freq(ref_clk)*((count+4)/(max_count-1))
else
    freq_min(det_clk) = freq(ref_clk)*((max_count+2)/(count+1))
    freq_max(det_clk) = freq(ref_clk)*((max_count+4)/(count-1))</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ref_clk_faster</spirit:name>
                     <spirit:description>This field determines if the reference clock (CPU Clock) is faster than the measured clock (Active-High)</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>max_count</spirit:name>
                     <spirit:description>This is the value used for the i_counter_max port of the freq_det module.</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>clk_sel</spirit:name>
                     <spirit:description>This field determines which clock is going to be measured:
0 : XMII RX Clock
1 : GE CLM RX Clock
2-7 : Reserved</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>3</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>go</spirit:name>
                     <spirit:description>Write a 1 to initiate frequency detection. HW will clear this field upon completion. Once cleared the frequency calculation can be done.
</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <rtl.hw_clear>1</rtl.hw_clear>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80002020</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>freq_det_dp</spirit:name>
                  <spirit:description>Frequency Detect DP register</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>count</spirit:name>
                     <spirit:description>Count value used for frequency calculation:
 if (ref_clk_faster)
    freq_min(det_clk) = freq(ref_clk)*((count+2)/(max_count+1))
    freq_max(det_clk) = freq(ref_clk)*((count+4)/(max_count-1))
else
    freq_min(det_clk) = freq(ref_clk)*((max_count+2)/(count+1))
    freq_max(det_clk) = freq(ref_clk)*((max_count+4)/(count-1))</spirit:description>
                     <spirit:bitOffset>18</spirit:bitOffset>
                     <spirit:bitWidth>14</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ref_clk_faster</spirit:name>
                     <spirit:description>This field determines if the reference clock (CPU Clock) is faster than the measured clock (Active-High)</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>max_count</spirit:name>
                     <spirit:description>This is the value used for the i_counter_max port of the freq_det module.</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>14</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>clk_sel</spirit:name>
                     <spirit:description>This field determines which clock is going to be measured:
0 : DP GTREFCLK1 (TX Reference Clock)
1 : DP GTREFCLK0 (RX Recovered Clock)
2-7 : Reserved</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>go</spirit:name>
                     <spirit:description>Write a 1 to initiate frequency detection. HW will clear this field upon completion. Once cleared the frequency calculation can be done.
</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <rtl.hw_clear>1</rtl.hw_clear>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80002024</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>freq_det_dp_auto</spirit:name>
                  <spirit:description>Frequency Detect DP Auto register</spirit:description>
                  <spirit:addressOffset>0x10</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>auto_enable</spirit:name>
                     <spirit:description>Automatic Mode Enable:
0 : Manual Mode
1 : Automatic Mode</spirit:description>
                     <spirit:bitOffset>31</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>comp_ref_clk_faster</spirit:name>
                     <spirit:description>In automatic mode the freq_det_dp.ref_clk_faster gets compared with this value</spirit:description>
                     <spirit:bitOffset>30</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>comp_count_max</spirit:name>
                     <spirit:description>In automatic mode the freq_det_dp.count gets compared with this value</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>14</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>comp_count_min</spirit:name>
                     <spirit:description>In automatic mode the freq_det_dp.count gets compared with this value</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>14</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80002028</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80002018</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : gcm  --> 

  <!-- reg group
                    :irq  --> 
          <spirit:registerFile>
               <spirit:name>irq</spirit:name>
               <spirit:description>BlackBird Top Interrupt register group</spirit:description>
               <spirit:addressOffset>0x2C</spirit:addressOffset>
               <spirit:range>0x10</spirit:range>            
               <spirit:register>
                  <spirit:name>enable</spirit:name>
                  <spirit:description>Interrupt Enable register - Write 1 to enable, 0 to mask an interrupt
</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>freq_det_dp_oor</spirit:name>
                     <spirit:description>Frequency Detect DP Out Of Range</spirit:description>
                     <spirit:bitOffset>18</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rxaui_gt1_rx_buf_overflow</spirit:name>
                     <spirit:description>RXAUI GT1 RX Elastic Buffer Overflow (RXBUFSTATUS was 3'b110)</spirit:description>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rxaui_gt1_rx_buf_underflow</spirit:name>
                     <spirit:description>RXAUI GT1 RX Elastic Buffer Underflow (RXBUFSTATUS was 3'b101)</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rxaui_gt0_rx_buf_overflow</spirit:name>
                     <spirit:description>RXAUI GT0 RX Elastic Buffer Overflow (RXBUFSTATUS was 3'b110)</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rxaui_gt0_rx_buf_underflow</spirit:name>
                     <spirit:description>RXAUI GT0 RX Elastic Buffer Underflow (RXBUFSTATUS was 3'b101)</spirit:description>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sl_5g_rx_buf_overflow</spirit:name>
                     <spirit:description>SL 5G RX Elastic Buffer Overflow (RXBUFSTATUS was 3'b110)</spirit:description>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sl_5g_rx_buf_underflow</spirit:name>
                     <spirit:description>SL 5G RX Elastic Buffer Underflow (RXBUFSTATUS was 3'b101)</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sl_5g_rx_fsm_reset_done</spirit:name>
                     <spirit:description>SL 5G RX FSM Reset Done Interrupt</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sl_5g_tx_fsm_reset_done</spirit:name>
                     <spirit:description>SL 5G TX FSM Reset Done Interrupt</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rxaui_align_status</spirit:name>
                     <spirit:description>RXAUI Align Status Interrupt</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ulp_phy_clk_lock</spirit:name>
                     <spirit:description>ULP PHY Clock PLL Lock Interrupt</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>xadc_ot</spirit:name>
                     <spirit:description>XADC Over-Temperature Alarm Interrupt</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>xadc_vbram</spirit:name>
                     <spirit:description>XADC VBRAM Sensor Alarm Interrupt</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>xadc_vccaux</spirit:name>
                     <spirit:description>XADC VCCAUX Sensor Alarm Interrupt</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>xadc_vccint</spirit:name>
                     <spirit:description>XADC VCCINT Sensor Alarm Interrupt</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>xadc_user_temp</spirit:name>
                     <spirit:description>XADC Temperature Sensor Alarm Interrupt</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>usb_vbus_detect</spirit:name>
                     <spirit:description>USB VBUS Detect Interrupt</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mdio_int_b</spirit:name>
                     <spirit:description>MDIO Interrupt</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sfp_los</spirit:name>
                     <spirit:description>SFP+ Module Connector LOS Interrupt</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000202C</address>
                        <intr.enable>irq0_bb_top</intr.enable>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending</spirit:name>
                  <spirit:description>Pending register - This indicates which events are pending, Write 1 to clear
</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>freq_det_dp_oor</spirit:name>
                     <spirit:description>Edge-triggered - Active-High
Frequency Detect DP Out Of Range</spirit:description>
                     <spirit:bitOffset>18</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rxaui_gt1_rx_buf_overflow</spirit:name>
                     <spirit:description>Edge-triggered - Active-High
RXAUI GT1 RX Elastic Buffer Overflow</spirit:description>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rxaui_gt1_rx_buf_underflow</spirit:name>
                     <spirit:description>Edge-triggered - Active-High
RXAUI GT1 RX Elastic Buffer Underflow</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rxaui_gt0_rx_buf_overflow</spirit:name>
                     <spirit:description>Edge-triggered - Active-High
RXAUI GT0 RX Elastic Buffer Overflow</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rxaui_gt0_rx_buf_underflow</spirit:name>
                     <spirit:description>Edge-triggered - Active-High
RXAUI GT0 RX Elastic Buffer Underflow</spirit:description>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sl_5g_rx_buf_overflow</spirit:name>
                     <spirit:description>Edge-triggered - Active-High
SL 5G RX Elastic Buffer Overflow</spirit:description>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sl_5g_rx_buf_underflow</spirit:name>
                     <spirit:description>Edge-triggered - Active-High
SL 5G RX Elastic Buffer Underflow</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sl_5g_rx_fsm_reset_done</spirit:name>
                     <spirit:description>Edge-triggered - Rising and Falling Edge
SL 5G RX FSM Reset Done</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sl_5g_tx_fsm_reset_done</spirit:name>
                     <spirit:description>Edge-triggered - Active-High
SL 5G TX FSM Reset Done</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rxaui_align_status</spirit:name>
                     <spirit:description>Edge-triggered - Rising and Falling Edge
RXAUI Align Status</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ulp_phy_clk_lock</spirit:name>
                     <spirit:description>Edge-triggered - Active High
ULP PHY Clock PLL Lock</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>xadc_ot</spirit:name>
                     <spirit:description>Edge-triggered - Active High
XADC Over-Temperature Alarm</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>xadc_vbram</spirit:name>
                     <spirit:description>Edge-triggered - Active High
XADC VBRAM Sensor Alarm</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>xadc_vccaux</spirit:name>
                     <spirit:description>Edge-triggered - Active High
XADC VCCAUX Sensor Alarm</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>xadc_vccint</spirit:name>
                     <spirit:description>Edge-triggered - Active High
XADC VCCINT Sensor Alarm</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>xadc_user_temp</spirit:name>
                     <spirit:description>Edge-triggered - Active High
XADC Temperature Sensor Alarm</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>usb_vbus_detect</spirit:name>
                     <spirit:description>Edge-triggered - Rising and Falling Edge
USB VBUS Detect change</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mdio_int_b</spirit:name>
                     <spirit:description>Level-triggered - Active-Low
MDIO Interrupt</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sfp_los</spirit:name>
                     <spirit:description>Edge-triggered - Rising and Falling Edge
SFP+ Module Connector LOS change</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80002030</address>
                        <intr.status>irq0_bb_top</intr.status>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending_irq</spirit:name>
                  <spirit:description>Interrupt Pending register - This indicates which pending events are enabled to cause an interrupt
</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>freq_det_dp_oor</spirit:name>
                     <spirit:description>Edge-triggered - Active-High
Frequency Detect DP Out Of Range</spirit:description>
                     <spirit:bitOffset>18</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rxaui_gt1_rx_buf_overflow</spirit:name>
                     <spirit:description>Edge-triggered - Active-High
RXAUI GT1 RX Elastic Buffer Overflow</spirit:description>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rxaui_gt1_rx_buf_underflow</spirit:name>
                     <spirit:description>Edge-triggered - Active-High
RXAUI GT1 RX Elastic Buffer Underflow</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rxaui_gt0_rx_buf_overflow</spirit:name>
                     <spirit:description>Edge-triggered - Active-High
RXAUI GT0 RX Elastic Buffer Overflow</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rxaui_gt0_rx_buf_underflow</spirit:name>
                     <spirit:description>Edge-triggered - Active-High
RXAUI GT0 RX Elastic Buffer Underflow</spirit:description>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sl_5g_rx_buf_overflow</spirit:name>
                     <spirit:description>Edge-triggered - Active-High
SL 5G RX Elastic Buffer Overflow</spirit:description>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sl_5g_rx_buf_underflow</spirit:name>
                     <spirit:description>Edge-triggered - Active-High
SL 5G RX Elastic Buffer Underflow</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sl_5g_rx_fsm_reset_done</spirit:name>
                     <spirit:description>Edge-triggered - Rising and Falling Edge
SL 5G RX FSM Reset Done</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sl_5g_tx_fsm_reset_done</spirit:name>
                     <spirit:description>Edge-triggered - Active-High
SL 5G TX FSM Reset Done</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rxaui_align_status</spirit:name>
                     <spirit:description>Edge-triggered - Rising and Falling Edge
RXAUI Align Status</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ulp_phy_clk_lock</spirit:name>
                     <spirit:description>Edge-triggered - Active High
ULP PHY Clock PLL Lock</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>xadc_ot</spirit:name>
                     <spirit:description>Edge-triggered - Active High
XADC Over-Temperature Alarm</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>xadc_vbram</spirit:name>
                     <spirit:description>Edge-triggered - Active High
XADC VBRAM Sensor Alarm</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>xadc_vccaux</spirit:name>
                     <spirit:description>Edge-triggered - Active High
XADC VCCAUX Sensor Alarm</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>xadc_vccint</spirit:name>
                     <spirit:description>Edge-triggered - Active High
XADC VCCINT Sensor Alarm</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>xadc_user_temp</spirit:name>
                     <spirit:description>Edge-triggered - Active High
XADC Temperature Sensor Alarm</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>usb_vbus_detect</spirit:name>
                     <spirit:description>Edge-triggered - Rising and Falling Edge
USB VBUS Detect change</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mdio_int_b</spirit:name>
                     <spirit:description>Level-triggered - Active-Low
MDIO Interrupt</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sfp_los</spirit:name>
                     <spirit:description>Edge-triggered - Rising and Falling Edge
SFP+ Module Connector LOS change</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80002034</address>
                        <intr.pending>irq0_bb_top</intr.pending>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>raw</spirit:name>
                  <spirit:description>This register contains the registered state of interrupt signals</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>freq_det_dp_oor</spirit:name>
                     <spirit:description>Current state of the Frequency Detect DP Out Of Range (Active-High)</spirit:description>
                     <spirit:bitOffset>18</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rxaui_gt1_rx_buf_overflow</spirit:name>
                     <spirit:description>Current state of the RXAUI GT1 RX Elastic Buffer Overflow (Active-High)</spirit:description>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rxaui_gt1_rx_buf_underflow</spirit:name>
                     <spirit:description>Current state of the RXAUI GT1 RX Elastic Buffer Underflow (Active-High)</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rxaui_gt0_rx_buf_overflow</spirit:name>
                     <spirit:description>Current state of the RXAUI GT0 RX Elastic Buffer Overflow (Active-High)</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rxaui_gt0_rx_buf_underflow</spirit:name>
                     <spirit:description>Current state of the RXAUI GT0 RX Elastic Buffer Underflow (Active-High)</spirit:description>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sl_5g_rx_buf_overflow</spirit:name>
                     <spirit:description>Current state of the SL 5G RX Elastic Buffer Overflow (Active-High)</spirit:description>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sl_5g_rx_buf_underflow</spirit:name>
                     <spirit:description>Current state of the SL 5G RX Elastic Buffer Underflow (Active-High)</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sl_5g_rx_fsm_reset_done</spirit:name>
                     <spirit:description>Current state of the SL 5G RX FSM Reset Done (Active-High)</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sl_5g_tx_fsm_reset_done</spirit:name>
                     <spirit:description>Current state of the SL 5G TX FSM Reset Done (Active-High)</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rxaui_align_status</spirit:name>
                     <spirit:description>Current state of the RXAUI Align Status (Active-High)</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ulp_phy_clk_lock</spirit:name>
                     <spirit:description>Current state of the ULP PHY Clock PLL Lock (Active-High)</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>xadc_ot</spirit:name>
                     <spirit:description>Current state of the XADC Over-Temperature Alarm (Active-High)</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>xadc_vbram</spirit:name>
                     <spirit:description>Current state of the XADC VBRAM Sensor Alarm (Active-High)</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>xadc_vccaux</spirit:name>
                     <spirit:description>Current state of the XADC VCCAUX Sensor Alarm (Active-High)</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>xadc_vccint</spirit:name>
                     <spirit:description>Current state of the XADC VCCINT Sensor Alarm (Active-High)</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>xadc_user_temp</spirit:name>
                     <spirit:description>Current state of the XADC Temperature Sensor Alarm (Active-High)</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>usb_vbus_detect</spirit:name>
                     <spirit:description>Current state of the USB VBUS Detect (Active-High)</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mdio_int_b</spirit:name>
                     <spirit:description>Current state of the MDIO Interrupt (Active-Low)</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sfp_los</spirit:name>
                     <spirit:description>Current state of the SFP+ Module Connector LOS (Active-High)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80002038</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x8000202C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : irq  --> 
            <spirit:register>
               <spirit:name>link_ctrl</spirit:name>
               <spirit:description>Link Control</spirit:description>
               <spirit:addressOffset>0x3C</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>sel</spirit:name>
                  <spirit:description>Link Select
0 : RXAUI
1 : SL 5G</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x8000203C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>mdio_ctrl</spirit:name>
               <spirit:description>MDIO Control</spirit:description>
               <spirit:addressOffset>0x40</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000001</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>master_bus_sel</spirit:name>
                  <spirit:description>MDIO Master Bus Select
0 : Mother board (connector)
1 : RXAUI Core (internal)</spirit:description>
                  <spirit:bitOffset>4</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>master_mdc_tri</spirit:name>
                  <spirit:description>MDIO Master Clock (MDC) Tri-State (Active-High)</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>1</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80002040</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>i2c_ctrl</spirit:name>
               <spirit:description>I2C Control</spirit:description>
               <spirit:addressOffset>0x44</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000001</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>master_bus_sel</spirit:name>
                  <spirit:description>I2C Master Bus Select
0 : Core board (local)
1 : Mother board (connector)</spirit:description>
                  <spirit:bitOffset>4</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>master_scl_tri</spirit:name>
                  <spirit:description>I2C Master Clock (SCL) Tri-State (Active-High)</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>1</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80002044</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>uart_ctrl</spirit:name>
               <spirit:description>UART Control</spirit:description>
               <spirit:addressOffset>0x48</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>ge_uart_sel</spirit:name>
                  <spirit:description>GE UART Select
0 : Mother board (connector)
1 : GE UART (internal)</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80002048</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>sfp_ctrl</spirit:name>
               <spirit:description>SFP Control</spirit:description>
               <spirit:addressOffset>0x4C</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000013</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>tx_disable</spirit:name>
                  <spirit:description>Transmitter Disable
0 : Module transmitter enabled
1 : Module transmitter disabled</spirit:description>
                  <spirit:bitOffset>4</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>1</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>rs1</spirit:name>
                  <spirit:description>Rate Select TX
0 : TX signalling rate less than or equal to 4.25 GBd
1 : TX signalling rate greater than 4.25 GBd</spirit:description>
                  <spirit:bitOffset>1</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>1</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>rs0</spirit:name>
                  <spirit:description>Rate Select RX
0 : RX signalling rate less than or equal to 4.25 GBd
1 : RX signalling rate greater than 4.25 GBd</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>1</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x8000204C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>sfp_status</spirit:name>
               <spirit:description>SFP Status</spirit:description>
               <spirit:addressOffset>0x50</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>rx_los</spirit:name>
                  <spirit:description>RX LOS (Active-High) - Indicates an optical signal level below that specified in the relevant standard</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>tx_fault</spirit:name>
                  <spirit:description>TX Fault (Active-High) - Module transmitter detected a fault</spirit:description>
                  <spirit:bitOffset>4</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>mod_abs</spirit:name>
                  <spirit:description>Module Absent (Active-High) - SFP+ module is physically absent</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80002050</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>usb3phy_ctrl</spirit:name>
               <spirit:description>USB3PHY Control</spirit:description>
               <spirit:addressOffset>0x54</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>force_tx_elec_idle</spirit:name>
                  <spirit:description>When this is set to 1, it forces the FPGA PIPE TX to Electrical Idle. Only used for hardware test to isolate the PIPE RX path from cross talk of TX path.</spirit:description>
                  <spirit:bitOffset>20</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>strapping_done</spirit:name>
                  <spirit:description>This register is used for dynamic strapping to select the proper path for strap options: xtal_dis and ssc_dis.
Assert high when strapping is completed (This should be asserted after PHY is out of reset using rst_b). See also "out_enable"</spirit:description>
                  <spirit:bitOffset>18</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>xtal_dis</spirit:name>
                  <spirit:description>Strap Option - Selects an input clock source
0 : Crystal input
1 : Clock input</spirit:description>
                  <spirit:bitOffset>17</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>ssc_dis</spirit:name>
                  <spirit:description>Strap Option - Spread spectrum clocking disable
0 : SSC enable
1 : SSC disable</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>power_present</spirit:name>
                  <spirit:description>Power Present to the ULP</spirit:description>
                  <spirit:bitOffset>9</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>power_present_sel</spirit:name>
                  <spirit:description>Power Present Select for the ULP:
0 : VBUS Detect
1 : usb3phy_ctrl.power_present register field</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>out_enable</spirit:name>
                  <spirit:description>Assert high to enable PHY outputs. Assert after PHY is out of reset and when dynamic strapping is complete. See rst_b and strapping_done.</spirit:description>
                  <spirit:bitOffset>4</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>tx_clk_en</spirit:name>
                  <spirit:description>Forwarded TX Clock Enable (Active-High)</spirit:description>
                  <spirit:bitOffset>1</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>rst_b</spirit:name>
                  <spirit:description>Reset (Active-Low)</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80002054</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>ge_ctrl</spirit:name>
               <spirit:description>GE Control</spirit:description>
               <spirit:addressOffset>0x58</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000100</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>int_n</spirit:name>
                  <spirit:description>Interrupt (Active-Low)</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>1</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>vbus_det</spirit:name>
                  <spirit:description>VBUS Detect (Active-High)</spirit:description>
                  <spirit:bitOffset>4</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>clm_tx_clk_en</spirit:name>
                  <spirit:description>Forwarded CLM TX Clock Enable (Active-High)</spirit:description>
                  <spirit:bitOffset>3</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>ref_clk_en</spirit:name>
                  <spirit:description>125 MHz Reference Clock Enable (Active-High)</spirit:description>
                  <spirit:bitOffset>2</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>boot_sel</spirit:name>
                  <spirit:description>Boot Select
0 : Program Mode
1 : Boot from Flash</spirit:description>
                  <spirit:bitOffset>1</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>rst_b</spirit:name>
                  <spirit:description>Reset (Active-Low)</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80002058</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>xmii_ctrl</spirit:name>
               <spirit:description>XMII Control</spirit:description>
               <spirit:addressOffset>0x5C</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>txd_tri</spirit:name>
                  <spirit:description>TXD Tri-State (Active-High)</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>tx_er_tri</spirit:name>
                  <spirit:description>TX ER Tri-State (Active-High)</spirit:description>
                  <spirit:bitOffset>5</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>tx_en_tri</spirit:name>
                  <spirit:description>TX EN Tri-State (Active-High)</spirit:description>
                  <spirit:bitOffset>4</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>gtx_clk_en</spirit:name>
                  <spirit:description>Forwarded GTX Clock Enable (Active-High)</spirit:description>
                  <spirit:bitOffset>1</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>rst_b</spirit:name>
                  <spirit:description>Reset (Active-Low)</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x8000205C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>rs232_ctrl</spirit:name>
               <spirit:description>RS232 Control</spirit:description>
               <spirit:addressOffset>0x60</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>invalid_b</spirit:name>
                  <spirit:description>Receiver Input (RIN) Invalid (Active-Low)</spirit:description>
                  <spirit:bitOffset>4</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>force_off_b</spirit:name>
                  <spirit:description>Automatic Power-Down (Active-Low)</spirit:description>
                  <spirit:bitOffset>1</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>en_b</spirit:name>
                  <spirit:description>Receiver Output (ROUT) Enable (Active-Low)</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80002060</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>
  <!-- reg group
                    :drp  --> 
          <spirit:registerFile>
               <spirit:name>drp</spirit:name>
               <spirit:description>DRP register group</spirit:description>
               <spirit:addressOffset>0x100</spirit:addressOffset>
               <spirit:range>0xC</spirit:range>            
               <spirit:register>
                  <spirit:name>drp_ctrl</spirit:name>
                  <spirit:description>DRP Control and Write Data.
Note: make sure this register is setup before writing to the drp_en_mask register</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>drp_di</spirit:name>
                     <spirit:description>DRP Write Data</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>drp_we</spirit:name>
                     <spirit:description>DRP Write Enable</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>drp_addr</spirit:name>
                     <spirit:description>DRP Address</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>9</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80002100</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>drp_en_mask</spirit:name>
                  <spirit:description>DRP Enable Mask for each DRP bus.
- A write to this register initiates a transaction to each enabled DRP bus.
- A field gets cleared when its respective DRP bus asserts DRPRDY.
Note: before attempting a new transaction, make sure no DRP bus is busy (all fields should be cleared)
Note: always enable exactly 1 DRP bus for read transfers, write transfers can have any combination of DRP buses enabled
Note: following a read transaction make sure the DRP bus has asserted DRPRDY (its DRP Enable Mask field should be cleared) before reading the drp_read_data register.</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>xadc</spirit:name>
                     <spirit:description>DRP Enable Mask for XADC
</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <rtl.hw_clear>1</rtl.hw_clear>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sl_5g_gt0</spirit:name>
                     <spirit:description>DRP Enable Mask for SL 5G GT0
</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <rtl.hw_clear>1</rtl.hw_clear>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rxaui_gt1</spirit:name>
                     <spirit:description>DRP Enable Mask for RXAUI GT1
</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <rtl.hw_clear>1</rtl.hw_clear>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rxaui_gt0</spirit:name>
                     <spirit:description>DRP Enable Mask for RXAUI GT0
</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <rtl.hw_clear>1</rtl.hw_clear>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>link_mmcm</spirit:name>
                     <spirit:description>DRP Enable Mask for Link MMCM
</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <rtl.hw_clear>1</rtl.hw_clear>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>link_gt_common</spirit:name>
                     <spirit:description>DRP Enable Mask for Link GT COMMON
</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <rtl.hw_clear>1</rtl.hw_clear>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_gt_rxoutclk_mmcm</spirit:name>
                     <spirit:description>DRP Enable Mask for DP GT RXOUTCLK MMCM
</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <rtl.hw_clear>1</rtl.hw_clear>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_gt_txoutclk_mmcm</spirit:name>
                     <spirit:description>DRP Enable Mask for DP GT TXOUTCLK MMCM
</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <rtl.hw_clear>1</rtl.hw_clear>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_gt_common</spirit:name>
                     <spirit:description>DRP Enable Mask for DP GT COMMON
</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <rtl.hw_clear>1</rtl.hw_clear>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_gt3</spirit:name>
                     <spirit:description>DRP Enable Mask for DP GT3
</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <rtl.hw_clear>1</rtl.hw_clear>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_gt2</spirit:name>
                     <spirit:description>DRP Enable Mask for DP GT2
</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <rtl.hw_clear>1</rtl.hw_clear>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_gt1</spirit:name>
                     <spirit:description>DRP Enable Mask for DP GT1
</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <rtl.hw_clear>1</rtl.hw_clear>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_gt0</spirit:name>
                     <spirit:description>DRP Enable Mask for DP GT0

</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <rtl.hw_clear>1</rtl.hw_clear>
                           <rtl.hw_wp>1</rtl.hw_wp>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80002104</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>drp_read_data</spirit:name>
                  <spirit:description>DRP Read Data
Note: make sure the DRP bus has asserted DRPRDY (its DRP Enable Mask field in the drp_en_mask register should be cleared) before reading this register</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>drp_do</spirit:name>
                     <spirit:description>DRP Read Data</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80002108</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80002100</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : drp  --> 

  <!-- reg group
                    :dp_gtp_common  --> 
          <spirit:registerFile>
               <spirit:name>dp_gtp_common</spirit:name>
               <spirit:description>DisplayPort GTP common register group</spirit:description>
               <spirit:addressOffset>0x10C</spirit:addressOffset>
               <spirit:range>0xC</spirit:range>            
               <spirit:register>
                  <spirit:name>pll_ctrl</spirit:name>
                  <spirit:description>PLL Control</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000113</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>pll1refclksel</spirit:name>
                     <spirit:description>PLL1REFCLKSEL (See UG482, Table 2-8)</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>3</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>001</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>pll0refclksel</spirit:name>
                     <spirit:description>PLL0REFCLKSEL (See UG482, Table 2-8)</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>3</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>001</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>pll1pd</spirit:name>
                     <spirit:description>PLL1PD (Active-High) (See UG482, Table 2-8)</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>pll0pd</spirit:name>
                     <spirit:description>PLL0PD (Active-High) (See UG482, Table 2-8)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000210C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pll_status</spirit:name>
                  <spirit:description>PLL Status</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>pll1refclklost</spirit:name>
                     <spirit:description>PLL1REFCLKLOST (Active-High) (See UG482, Table 2-8)</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>pll0refclklost</spirit:name>
                     <spirit:description>PLL0REFCLKLOST (Active-High) (See UG482, Table 2-8)</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>pll1lock</spirit:name>
                     <spirit:description>PLL1LOCK (Active-High) (See UG482, Table 2-8)</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>pll0lock</spirit:name>
                     <spirit:description>PLL0LOCK (Active-High) (See UG482, Table 2-8)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80002110</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>loopback_ctrl</spirit:name>
                  <spirit:description>Loopback Control</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>gt3_loopback</spirit:name>
                     <spirit:description>GT3 LOOPBACK (See UG482, Table 2-27)</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>3</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt2_loopback</spirit:name>
                     <spirit:description>GT2 LOOPBACK (See UG482, Table 2-27)</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>3</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_loopback</spirit:name>
                     <spirit:description>GT1 LOOPBACK (See UG482, Table 2-27)</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>3</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_loopback</spirit:name>
                     <spirit:description>GT0 LOOPBACK (See UG482, Table 2-27)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>3</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80002114</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x8000210C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : dp_gtp_common  --> 

  <!-- reg group
                    :dp_gtp_tx  --> 
          <spirit:registerFile>
               <spirit:name>dp_gtp_tx</spirit:name>
               <spirit:description>DisplayPort GTP TX register group</spirit:description>
               <spirit:addressOffset>0x118</spirit:addressOffset>
               <spirit:range>0x20</spirit:range>            
               <spirit:register>
                  <spirit:name>tx_clk_ctrl</spirit:name>
                  <spirit:description>GTP TX Clock Control</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>gt3_txsysclksel</spirit:name>
                     <spirit:description>GT3 TXSYSCLKSEL (See UG482, Table 2-6)</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>2</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt2_txsysclksel</spirit:name>
                     <spirit:description>GT2 TXSYSCLKSEL (See UG482, Table 2-6)</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>2</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_txsysclksel</spirit:name>
                     <spirit:description>GT1 TXSYSCLKSEL (See UG482, Table 2-6)</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>2</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_txsysclksel</spirit:name>
                     <spirit:description>GT0 TXSYSCLKSEL (See UG482, Table 2-6)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>2</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80002118</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>tx_rst_ctrl</spirit:name>
                  <spirit:description>GTP TX Reset Control</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000001</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>gt3_txpcsreset</spirit:name>
                     <spirit:description>GT3 TXPCSRESET (Active-High) (See UG482, Table 2-14)</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt2_txpcsreset</spirit:name>
                     <spirit:description>GT2 TXPCSRESET (Active-High) (See UG482, Table 2-14)</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_txpcsreset</spirit:name>
                     <spirit:description>GT1 TXPCSRESET (Active-High) (See UG482, Table 2-14)</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_txpcsreset</spirit:name>
                     <spirit:description>GT0 TXPCSRESET (Active-High) (See UG482, Table 2-14)</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>soft_reset_tx</spirit:name>
                     <spirit:description>Soft Reset of TX path of all DP GTPs (Active-High)
1'b0 - All GTP TX Reset FSMs are out of reset
1'b1 - All GTP TX Reset FSMs are in reset
Note: To reset write a 1 followed by a 0</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000211C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>tx_status</spirit:name>
                  <spirit:description>GTP TX Status</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>gt_txoutclk_mmcm_lock</spirit:name>
                     <spirit:description>GT TXOUTCLK MMCM Lock (Active-High)</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt3_tx_fsm_reset_done</spirit:name>
                     <spirit:description>GT3 TX FSM Reset Done (Active-High)</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt2_tx_fsm_reset_done</spirit:name>
                     <spirit:description>GT2 TX FSM Reset Done (Active-High)</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_tx_fsm_reset_done</spirit:name>
                     <spirit:description>GT1 TX FSM Reset Done (Active-High)</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_tx_fsm_reset_done</spirit:name>
                     <spirit:description>GT0 TX FSM Reset Done (Active-High)</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt3_txresetdone</spirit:name>
                     <spirit:description>GT3 TXRESETDONE (Active-High) (See UG482, Table 2-14)</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt2_txresetdone</spirit:name>
                     <spirit:description>GT2 TXRESETDONE (Active-High) (See UG482, Table 2-14)</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_txresetdone</spirit:name>
                     <spirit:description>GT1 TXRESETDONE (Active-High) (See UG482, Table 2-14)</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_txresetdone</spirit:name>
                     <spirit:description>GT0 TXRESETDONE (Active-High) (See UG482, Table 2-14)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80002120</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>tx_diff_ctrl</spirit:name>
                  <spirit:description>GTP TX Voltage Swing</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00002222</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>gt3_txdiffctrl</spirit:name>
                     <spirit:description>GT3 TXDIFFCTRL (See UG482, Table 3-28)</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0010</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt2_txdiffctrl</spirit:name>
                     <spirit:description>GT2 TXDIFFCTRL (See UG482, Table 3-28)</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0010</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_txdiffctrl</spirit:name>
                     <spirit:description>GT1 TXDIFFCTRL (See UG482, Table 3-28)</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0010</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_txdiffctrl</spirit:name>
                     <spirit:description>GT0 TXDIFFCTRL (See UG482, Table 3-28)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0010</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80002124</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>tx_post_cursor</spirit:name>
                  <spirit:description>GTP TX Pre-emphasis (Post-Cursor1)</spirit:description>
                  <spirit:addressOffset>0x10</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>gt3_txpostcursor</spirit:name>
                     <spirit:description>GT3 TXPOSTCURSOR (See UG482, Table 3-28)</spirit:description>
                     <spirit:bitOffset>24</spirit:bitOffset>
                     <spirit:bitWidth>5</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt2_txpostcursor</spirit:name>
                     <spirit:description>GT2 TXPOSTCURSOR (See UG482, Table 3-28)</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>5</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_txpostcursor</spirit:name>
                     <spirit:description>GT1 TXPOSTCURSOR (See UG482, Table 3-28)</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>5</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_txpostcursor</spirit:name>
                     <spirit:description>GT0 TXPOSTCURSOR (See UG482, Table 3-28)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>5</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80002128</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>tx_pre_cursor</spirit:name>
                  <spirit:description>GTP TX Pre-emphasis (Pre-Cursor)</spirit:description>
                  <spirit:addressOffset>0x14</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>gt3_txprecursor</spirit:name>
                     <spirit:description>GT3 TXPRECURSOR (See UG482, Table 3-28)</spirit:description>
                     <spirit:bitOffset>24</spirit:bitOffset>
                     <spirit:bitWidth>5</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt2_txprecursor</spirit:name>
                     <spirit:description>GT2 TXPRECURSOR (See UG482, Table 3-28)</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>5</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_txprecursor</spirit:name>
                     <spirit:description>GT1 TXPRECURSOR (See UG482, Table 3-28)</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>5</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_txprecursor</spirit:name>
                     <spirit:description>GT0 TXPRECURSOR (See UG482, Table 3-28)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>5</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000212C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>tx_prbs_ctrl</spirit:name>
                  <spirit:description>GTP TX Pattern Generator Control</spirit:description>
                  <spirit:addressOffset>0x18</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>gt3_txprbsforceerr</spirit:name>
                     <spirit:description>GT3 TXPRBSFORCEERR (Active-High) (See UG482, Table 3-20)</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt3_txprbssel</spirit:name>
                     <spirit:description>GT3 TXPRBSSEL (See UG482, Table 3-20)</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>3</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt2_txprbsforceerr</spirit:name>
                     <spirit:description>GT2 TXPRBSFORCEERR (Active-High) (See UG482, Table 3-20)</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt2_txprbssel</spirit:name>
                     <spirit:description>GT2 TXPRBSSEL (See UG482, Table 3-20)</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>3</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_txprbsforceerr</spirit:name>
                     <spirit:description>GT1 TXPRBSFORCEERR (Active-High) (See UG482, Table 3-20)</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_txprbssel</spirit:name>
                     <spirit:description>GT1 TXPRBSSEL (See UG482, Table 3-20)</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>3</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_txprbsforceerr</spirit:name>
                     <spirit:description>GT0 TXPRBSFORCEERR (Active-High) (See UG482, Table 3-20)</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_txprbssel</spirit:name>
                     <spirit:description>GT0 TXPRBSSEL (See UG482, Table 3-20)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>3</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80002130</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>tx_misc_ctrl</spirit:name>
                  <spirit:description>GTP TX Miscellaneous Control</spirit:description>
                  <spirit:addressOffset>0x1C</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x0000FFF0</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>gt3_txinhibit</spirit:name>
                     <spirit:description>GT3 TXINHIBIT (Active-High) (See UG482, Table 3-28)</spirit:description>
                     <spirit:bitOffset>19</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt2_txinhibit</spirit:name>
                     <spirit:description>GT2 TXINHIBIT (Active-High) (See UG482, Table 3-28)</spirit:description>
                     <spirit:bitOffset>18</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_txinhibit</spirit:name>
                     <spirit:description>GT1 TXINHIBIT (Active-High) (See UG482, Table 3-28)</spirit:description>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_txinhibit</spirit:name>
                     <spirit:description>GT0 TXINHIBIT (Active-High) (See UG482, Table 3-28)</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt3_txpd</spirit:name>
                     <spirit:description>GT3 TXPD (See UG482, Table 3-30)</spirit:description>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>2</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>11</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt2_txpd</spirit:name>
                     <spirit:description>GT2 TXPD (See UG482, Table 3-30)</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>2</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>11</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_txpd</spirit:name>
                     <spirit:description>GT1 TXPD (See UG482, Table 3-30)</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>2</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>11</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_txpd</spirit:name>
                     <spirit:description>GT0 TXPD (See UG482, Table 3-30)</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>2</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>11</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt3_tx8b10ben</spirit:name>
                     <spirit:description>GT3 TX8B10BEN (Active-High) (See UG482, Table 3-7)</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt2_tx8b10ben</spirit:name>
                     <spirit:description>GT2 TX8B10BEN (Active-High) (See UG482, Table 3-7)</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_tx8b10ben</spirit:name>
                     <spirit:description>GT1 TX8B10BEN (Active-High) (See UG482, Table 3-7)</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_tx8b10ben</spirit:name>
                     <spirit:description>GT0 TX8B10BEN (Active-High) (See UG482, Table 3-7)</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt3_txpolarity</spirit:name>
                     <spirit:description>GT3 TXPOLARITY (See UG482, Table 3-22)</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt2_txpolarity</spirit:name>
                     <spirit:description>GT2 TXPOLARITY (See UG482, Table 3-22)</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_txpolarity</spirit:name>
                     <spirit:description>GT1 TXPOLARITY (See UG482, Table 3-22)</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_txpolarity</spirit:name>
                     <spirit:description>GT0 TXPOLARITY (See UG482, Table 3-22)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80002134</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80002118</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : dp_gtp_tx  --> 

  <!-- reg group
                    :dp_gtp_rx  --> 
          <spirit:registerFile>
               <spirit:name>dp_gtp_rx</spirit:name>
               <spirit:description>DisplayPort GTP RX register group</spirit:description>
               <spirit:addressOffset>0x138</spirit:addressOffset>
               <spirit:range>0x2C</spirit:range>            
               <spirit:register>
                  <spirit:name>rx_clk_ctrl</spirit:name>
                  <spirit:description>GTP TX Clock Control</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>gt3_rxsysclksel</spirit:name>
                     <spirit:description>GT3 RXSYSCLKSEL (See UG482, Table 2-6)</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>2</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt2_rxsysclksel</spirit:name>
                     <spirit:description>GT2 RXSYSCLKSEL (See UG482, Table 2-6)</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>2</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_rxsysclksel</spirit:name>
                     <spirit:description>GT1 RXSYSCLKSEL (See UG482, Table 2-6)</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>2</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_rxsysclksel</spirit:name>
                     <spirit:description>GT0 RXSYSCLKSEL (See UG482, Table 2-6)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>2</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80002138</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>rx_rst_ctrl</spirit:name>
                  <spirit:description>GTP RX Reset Control</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000001</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>gt3_rxlpmreset</spirit:name>
                     <spirit:description>GT3 RXLPMRESET (Active-High) (See UG482, Table 4-18)</spirit:description>
                     <spirit:bitOffset>19</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt2_rxlpmreset</spirit:name>
                     <spirit:description>GT2 RXLPMRESET (Active-High) (See UG482, Table 4-18)</spirit:description>
                     <spirit:bitOffset>18</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_rxlpmreset</spirit:name>
                     <spirit:description>GT1 RXLPMRESET (Active-High) (See UG482, Table 4-18)</spirit:description>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_rxlpmreset</spirit:name>
                     <spirit:description>GT0 RXLPMRESET (Active-High) (See UG482, Table 4-18)</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt3_eyescanreset</spirit:name>
                     <spirit:description>GT3 EYESCANRESET (Active-High) (See UG482, Table 2-18)</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt2_eyescanreset</spirit:name>
                     <spirit:description>GT2 EYESCANRESET (Active-High) (See UG482, Table 2-18)</spirit:description>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_eyescanreset</spirit:name>
                     <spirit:description>GT1 EYESCANRESET (Active-High) (See UG482, Table 2-18)</spirit:description>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_eyescanreset</spirit:name>
                     <spirit:description>GT0 EYESCANRESET (Active-High) (See UG482, Table 2-18)</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt3_rxpmareset</spirit:name>
                     <spirit:description>GT3 RXPMARESET (Active-High) (See UG482, Table 2-18)</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt2_rxpmareset</spirit:name>
                     <spirit:description>GT2 RXPMARESET (Active-High) (See UG482, Table 2-18)</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_rxpmareset</spirit:name>
                     <spirit:description>GT1 RXPMARESET (Active-High) (See UG482, Table 2-18)</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_rxpmareset</spirit:name>
                     <spirit:description>GT0 RXPMARESET (Active-High) (See UG482, Table 2-18)</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt3_rxpcsreset</spirit:name>
                     <spirit:description>GT3 RXPCSRESET (Active-High) (See UG482, Table 2-18)</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt2_rxpcsreset</spirit:name>
                     <spirit:description>GT2 RXPCSRESET (Active-High) (See UG482, Table 2-18)</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_rxpcsreset</spirit:name>
                     <spirit:description>GT1 RXPCSRESET (Active-High) (See UG482, Table 2-18)</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_rxpcsreset</spirit:name>
                     <spirit:description>GT0 RXPCSRESET (Active-High) (See UG482, Table 2-18)</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dont_reset_on_data_error</spirit:name>
                     <spirit:description>Do not automatically reset the RX_STARTUP_FSM of a GTP when its DATA_VALID input de-asserts.</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>soft_reset_rx</spirit:name>
                     <spirit:description>Soft Reset of RX path of all DP GTPs (Active-High)
1'b0 - All GTP RX Reset FSMs are out of reset
1'b1 - All GTP RX Reset FSMs are in reset
Note: To reset write a 1 followed by a 0</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000213C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>rx_status</spirit:name>
                  <spirit:description>GTP RX Status</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>gt_rxoutclk_mmcm_lock</spirit:name>
                     <spirit:description>GT RXOUTCLK MMCM Lock (Active-High)</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt3_rx_fsm_reset_done</spirit:name>
                     <spirit:description>GT3 RX FSM Reset Done (Active-High)</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt2_rx_fsm_reset_done</spirit:name>
                     <spirit:description>GT2 RX FSM Reset Done (Active-High)</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_rx_fsm_reset_done</spirit:name>
                     <spirit:description>GT1 RX FSM Reset Done (Active-High)</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_rx_fsm_reset_done</spirit:name>
                     <spirit:description>GT0 RX FSM Reset Done (Active-High)</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt3_rxresetdone</spirit:name>
                     <spirit:description>GT3 RXRESETDONE (Active-High) (See UG482, Table 2-18)</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt2_rxresetdone</spirit:name>
                     <spirit:description>GT2 RXRESETDONE (Active-High) (See UG482, Table 2-18)</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_rxresetdone</spirit:name>
                     <spirit:description>GT1 RXRESETDONE (Active-High) (See UG482, Table 2-18)</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_rxresetdone</spirit:name>
                     <spirit:description>GT0 RXRESETDONE (Active-High) (See UG482, Table 2-18)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80002140</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>rx_byte_align_ctrl</spirit:name>
                  <spirit:description>GTP RX Byte Alignment Control</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x000000FF</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>gt3_rxpcommaalignen</spirit:name>
                     <spirit:description>GT3 RXPCOMMAALIGNEN (See UG482, Table 4-25)</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt2_rxpcommaalignen</spirit:name>
                     <spirit:description>GT2 RXPCOMMAALIGNEN (See UG482, Table 4-25)</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_rxpcommaalignen</spirit:name>
                     <spirit:description>GT1 RXPCOMMAALIGNEN (See UG482, Table 4-25)</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_rxpcommaalignen</spirit:name>
                     <spirit:description>GT0 RXPCOMMAALIGNEN (See UG482, Table 4-25)</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt3_rxmcommaalignen</spirit:name>
                     <spirit:description>GT3 RXMCOMMAALIGNEN (See UG482, Table 4-25)</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt2_rxmcommaalignen</spirit:name>
                     <spirit:description>GT2 RXMCOMMAALIGNEN (See UG482, Table 4-25)</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_rxmcommaalignen</spirit:name>
                     <spirit:description>GT1 RXMCOMMAALIGNEN (See UG482, Table 4-25)</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_rxmcommaalignen</spirit:name>
                     <spirit:description>GT0 RXMCOMMAALIGNEN (See UG482, Table 4-25)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80002144</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>rx_byte_align_status</spirit:name>
                  <spirit:description>GTP RX Byte Alignment Status</spirit:description>
                  <spirit:addressOffset>0x10</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>gt3_rxbyteisaligned</spirit:name>
                     <spirit:description>GT3 RXBYTEISALIGNED (See UG482, Table 4-25)</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt2_rxbyteisaligned</spirit:name>
                     <spirit:description>GT2 RXBYTEISALIGNED (See UG482, Table 4-25)</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_rxbyteisaligned</spirit:name>
                     <spirit:description>GT1 RXBYTEISALIGNED (See UG482, Table 4-25)</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_rxbyteisaligned</spirit:name>
                     <spirit:description>GT0 RXBYTEISALIGNED (See UG482, Table 4-25)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80002148</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>rx_prbs_ctrl</spirit:name>
                  <spirit:description>GTP RX Pattern Receiver Control</spirit:description>
                  <spirit:addressOffset>0x14</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>gt3_rxprbscntreset</spirit:name>
                     <spirit:description>GT3 RXPRBSCNTRESET (Active-High) (See UG482, Table 4-23)</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt3_rxprbssel</spirit:name>
                     <spirit:description>GT3 RXPRBSSEL (See UG482, Table 4-23)</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>3</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt2_rxprbscntreset</spirit:name>
                     <spirit:description>GT2 RXPRBSCNTRESET (Active-High) (See UG482, Table 4-23)</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt2_rxprbssel</spirit:name>
                     <spirit:description>GT2 RXPRBSSEL (See UG482, Table 4-23)</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>3</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_rxprbscntreset</spirit:name>
                     <spirit:description>GT1 RXPRBSCNTRESET (Active-High) (See UG482, Table 4-23)</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_rxprbssel</spirit:name>
                     <spirit:description>GT1 RXPRBSSEL (See UG482, Table 4-23)</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>3</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_rxprbscntreset</spirit:name>
                     <spirit:description>GT0 RXPRBSCNTRESET (Active-High) (See UG482, Table 4-23)</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_rxprbssel</spirit:name>
                     <spirit:description>GT0 RXPRBSSEL (See UG482, Table 4-23)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>3</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000214C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>rx_ph_monitor</spirit:name>
                  <spirit:description>GTP RX Phase Alignment Monitor</spirit:description>
                  <spirit:addressOffset>0x18</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>gt3_rxphmonitor</spirit:name>
                     <spirit:description>GT3 RXPHMONITOR (See UG482, Table 4-29)</spirit:description>
                     <spirit:bitOffset>24</spirit:bitOffset>
                     <spirit:bitWidth>5</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt2_rxphmonitor</spirit:name>
                     <spirit:description>GT2 RXPHMONITOR (See UG482, Table 4-29)</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>5</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_rxphmonitor</spirit:name>
                     <spirit:description>GT1 RXPHMONITOR (See UG482, Table 4-29)</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>5</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_rxphmonitor</spirit:name>
                     <spirit:description>GT0 RXPHMONITOR (See UG482, Table 4-29)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>5</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80002150</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>rx_ph_slip_monitor</spirit:name>
                  <spirit:description>GTP RX Phase Alignment Slip Monitor</spirit:description>
                  <spirit:addressOffset>0x1C</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>gt3_rxphslipmonitor</spirit:name>
                     <spirit:description>GT3 RXPHSLIPMONITOR (See UG482, Table 4-29)</spirit:description>
                     <spirit:bitOffset>24</spirit:bitOffset>
                     <spirit:bitWidth>5</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt2_rxphslipmonitor</spirit:name>
                     <spirit:description>GT2 RXPHSLIPMONITOR (See UG482, Table 4-29)</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>5</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_rxphslipmonitor</spirit:name>
                     <spirit:description>GT1 RXPHSLIPMONITOR (See UG482, Table 4-29)</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>5</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_rxphslipmonitor</spirit:name>
                     <spirit:description>GT0 RXPHSLIPMONITOR (See UG482, Table 4-29)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>5</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80002154</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>rx_dmonitor_out</spirit:name>
                  <spirit:description>GTP RX Digital Monitor Out</spirit:description>
                  <spirit:addressOffset>0x20</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>gt3_dmonitorout</spirit:name>
                     <spirit:description>GT3 DMONITOROUT[7:0] (See UG482, Table 2-31)</spirit:description>
                     <spirit:bitOffset>24</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt2_dmonitorout</spirit:name>
                     <spirit:description>GT2 DMONITOROUT[7:0] (See UG482, Table 2-31)</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_dmonitorout</spirit:name>
                     <spirit:description>GT1 DMONITOROUT[7:0] (See UG482, Table 2-31)</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_dmonitorout</spirit:name>
                     <spirit:description>GT0 DMONITOROUT[7:0] (See UG482, Table 2-31)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80002158</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>rx_eq_ctrl</spirit:name>
                  <spirit:description>GTP RX Equalizer Control</spirit:description>
                  <spirit:addressOffset>0x24</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>gt3_rxlpmlfhold</spirit:name>
                     <spirit:description>GT3 RXLPMLFHOLD (See UG482, Table 4-9)</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt2_rxlpmlfhold</spirit:name>
                     <spirit:description>GT2 RXLPMLFHOLD (See UG482, Table 4-9)</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_rxlpmlfhold</spirit:name>
                     <spirit:description>GT1 RXLPMLFHOLD (See UG482, Table 4-9)</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_rxlpmlfhold</spirit:name>
                     <spirit:description>GT0 RXLPMLFHOLD (See UG482, Table 4-9)</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt3_rxlpmhfovrden</spirit:name>
                     <spirit:description>GT3 RXLPMHFOVRDEN (See UG482, Table 4-9)</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt2_rxlpmhfovrden</spirit:name>
                     <spirit:description>GT2 RXLPMHFOVRDEN (See UG482, Table 4-9)</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_rxlpmhfovrden</spirit:name>
                     <spirit:description>GT1 RXLPMHFOVRDEN (See UG482, Table 4-9)</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_rxlpmhfovrden</spirit:name>
                     <spirit:description>GT0 RXLPMHFOVRDEN (See UG482, Table 4-9)</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt3_rxlpmhfhold</spirit:name>
                     <spirit:description>GT3 RXLPMHFHOLD (See UG482, Table 4-9)</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt2_rxlpmhfhold</spirit:name>
                     <spirit:description>GT2 RXLPMHFHOLD (See UG482, Table 4-9)</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_rxlpmhfhold</spirit:name>
                     <spirit:description>GT1 RXLPMHFHOLD (See UG482, Table 4-9)</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_rxlpmhfhold</spirit:name>
                     <spirit:description>GT0 RXLPMHFHOLD (See UG482, Table 4-9)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000215C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>rx_misc_ctrl</spirit:name>
                  <spirit:description>GTP RX Miscellaneous Control</spirit:description>
                  <spirit:addressOffset>0x28</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x0000FF00</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>gt_data_valid_en</spirit:name>
                     <spirit:description>DATA_VALID input to the GT RX_STARTUP_FSM is:
1'b0 : always 1
1'b1 : hardware defined (generally the NOT of the OR of all 8B/10B decode errors)</spirit:description>
                     <spirit:bitOffset>31</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt3_rxcdrhold</spirit:name>
                     <spirit:description>GT3 RXCDRHOLD (See UG482, Table 4-11)</spirit:description>
                     <spirit:bitOffset>19</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt2_rxcdrhold</spirit:name>
                     <spirit:description>GT2 RXCDRHOLD (See UG482, Table 4-11)</spirit:description>
                     <spirit:bitOffset>18</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_rxcdrhold</spirit:name>
                     <spirit:description>GT1 RXCDRHOLD (See UG482, Table 4-11)</spirit:description>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_rxcdrhold</spirit:name>
                     <spirit:description>GT0 RXCDRHOLD (See UG482, Table 4-11)</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt3_rxpd</spirit:name>
                     <spirit:description>GT3 RXPD (See UG482, Table 3-30)</spirit:description>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>2</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>11</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt2_rxpd</spirit:name>
                     <spirit:description>GT2 RXPD (See UG482, Table 3-30)</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>2</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>11</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_rxpd</spirit:name>
                     <spirit:description>GT1 RXPD (See UG482, Table 3-30)</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>2</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>11</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_rxpd</spirit:name>
                     <spirit:description>GT0 RXPD (See UG482, Table 3-30)</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>2</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>11</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt3_rxpolarity</spirit:name>
                     <spirit:description>GT3 RXPOLARITY (See UG482, Table 4-22)</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt2_rxpolarity</spirit:name>
                     <spirit:description>GT2 RXPOLARITY (See UG482, Table 4-22)</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_rxpolarity</spirit:name>
                     <spirit:description>GT1 RXPOLARITY (See UG482, Table 4-22)</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_rxpolarity</spirit:name>
                     <spirit:description>GT0 RXPOLARITY (See UG482, Table 4-22)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80002160</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80002138</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : dp_gtp_rx  --> 

  <!-- reg group
                    :rxaui  --> 
          <spirit:registerFile>
               <spirit:name>rxaui</spirit:name>
               <spirit:description>RXAUI register group</spirit:description>
               <spirit:addressOffset>0x164</spirit:addressOffset>
               <spirit:range>0x40</spirit:range>            
               <spirit:register>
                  <spirit:name>control</spirit:name>
                  <spirit:description>Control register</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000001</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>fix_missing_start</spirit:name>
                     <spirit:description>Replace the XGMII Idle with an XGMII Start control character when it is detected missing (see stats0.missing_start)</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>type_sel</spirit:name>
                     <spirit:description>Type Select (See PG083, Table 3-3)</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>2</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>reset</spirit:name>
                     <spirit:description>Asynchronous reset (Active-High)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80002164</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>status</spirit:name>
                  <spirit:description>Status register</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>debug</spirit:name>
                     <spirit:description>Debug Port (See PG083, Table 2-18)
[0] : TX Phase Align Complete
[4:1] : Sync Status
[5]: Align Status</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>6</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80002168</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>gt_rst_ctrl</spirit:name>
                  <spirit:description>GTP Reset Control register</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>gtrxreset</spirit:name>
                     <spirit:description>GT0 and GT1 GTRXRESET (Active-High) (See UG482, Table 2-18)</spirit:description>
                     <spirit:bitOffset>31</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_rxbufreset</spirit:name>
                     <spirit:description>GT1 RXBUFRESET (Active-High) (See UG482, Table 2-18)</spirit:description>
                     <spirit:bitOffset>21</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_rxbufreset</spirit:name>
                     <spirit:description>GT0 RXBUFRESET (Active-High) (See UG482, Table 2-18)</spirit:description>
                     <spirit:bitOffset>20</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_rxlpmreset</spirit:name>
                     <spirit:description>GT1 RXLPMRESET (Active-High) (See UG482, Table 2-18)</spirit:description>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_rxlpmreset</spirit:name>
                     <spirit:description>GT0 RXLPMRESET (Active-High) (See UG482, Table 2-18)</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_rxpcsreset</spirit:name>
                     <spirit:description>GT1 RXPCSRESET (Active-High) (See UG482, Table 2-18)</spirit:description>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_rxpcsreset</spirit:name>
                     <spirit:description>GT0 RXPCSRESET (Active-High) (See UG482, Table 2-18)</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_rxpmareset</spirit:name>
                     <spirit:description>GT1 RXPMARESET (Active-High) (See UG482, Table 2-18)</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_rxpmareset</spirit:name>
                     <spirit:description>GT0 RXPMARESET (Active-High) (See UG482, Table 2-18)</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_txpcsreset</spirit:name>
                     <spirit:description>GT1 TXPCSRESET (Active-High) (See UG482, Table 2-14)</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_txpcsreset</spirit:name>
                     <spirit:description>GT0 TXPCSRESET (Active-High) (See UG482, Table 2-14)</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_txpmareset</spirit:name>
                     <spirit:description>GT1 TXPMARESET (Active-High) (See UG482, Table 2-14)</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_txpmareset</spirit:name>
                     <spirit:description>GT0 TXPMARESET (Active-High) (See UG482, Table 2-14)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000216C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>gt_status</spirit:name>
                  <spirit:description>GTP Status register</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>gt1_rxpmaresetdone</spirit:name>
                     <spirit:description>GT1 RXPMARESETDONE (Active-High) (See UG482, Table 2-18)</spirit:description>
                     <spirit:bitOffset>19</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_rxpmaresetdone</spirit:name>
                     <spirit:description>GT0 RXPMARESETDONE (Active-High) (See UG482, Table 2-18)</spirit:description>
                     <spirit:bitOffset>18</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_txdlysresetdone</spirit:name>
                     <spirit:description>GT1 TXDLYSRESETDONE (Active-High) (See UG482, Table 3-15)</spirit:description>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_txdlysresetdone</spirit:name>
                     <spirit:description>GT0 TXDLYSRESETDONE (Active-High) (See UG482, Table 3-15)</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_txphinitdone</spirit:name>
                     <spirit:description>GT1 TXPHINITDONE (Active-High) (See UG482, Table 3-15)</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_txphinitdone</spirit:name>
                     <spirit:description>GT0 TXPHINITDONE (Active-High) (See UG482, Table 3-15)</spirit:description>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_txphaligndone</spirit:name>
                     <spirit:description>GT1 TXPHALIGNDONE (Active-High) (See UG482, Table 3-15)</spirit:description>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_txphaligndone</spirit:name>
                     <spirit:description>GT0 TXPHALIGNDONE (Active-High) (See UG482, Table 3-15)</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_rxbufstatus</spirit:name>
                     <spirit:description>GT1 RXBUFSTATUS (See UG482, Table 4-33)</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>3</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_rxbufstatus</spirit:name>
                     <spirit:description>GT0 RXBUFSTATUS (See UG482, Table 4-33)</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>3</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_rxresetdone</spirit:name>
                     <spirit:description>GT1 RXRESETDONE (Active-High) (See UG482, Table 2-18)</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_rxresetdone</spirit:name>
                     <spirit:description>GT0 RXRESETDONE (Active-High) (See UG482, Table 2-18)</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_txresetdone</spirit:name>
                     <spirit:description>GT1 TXRESETDONE (Active-High) (See UG482, Table 2-14)</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_txresetdone</spirit:name>
                     <spirit:description>GT0 TXRESETDONE (Active-High) (See UG482, Table 2-14)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80002170</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>gt_tx_diff_ctrl</spirit:name>
                  <spirit:description>GTP TX Voltage Swing</spirit:description>
                  <spirit:addressOffset>0x10</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x000000AA</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>gt1_txdiffctrl</spirit:name>
                     <spirit:description>GT1 TXDIFFCTRL (See UG482, Table 3-28)</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1010</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_txdiffctrl</spirit:name>
                     <spirit:description>GT0 TXDIFFCTRL (See UG482, Table 3-28)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1010</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80002174</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>gt_tx_post_cursor</spirit:name>
                  <spirit:description>GTP TX Pre-emphasis (Post-Cursor)</spirit:description>
                  <spirit:addressOffset>0x14</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>gt1_txpostcursor</spirit:name>
                     <spirit:description>GT1 TXPOSTCURSOR (See UG482, Table 3-28)</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>5</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_txpostcursor</spirit:name>
                     <spirit:description>GT0 TXPOSTCURSOR (See UG482, Table 3-28)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>5</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80002178</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>gt_tx_pre_cursor</spirit:name>
                  <spirit:description>GTP TX Pre-emphasis (Pre-Cursor)</spirit:description>
                  <spirit:addressOffset>0x18</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>gt1_txprecursor</spirit:name>
                     <spirit:description>GT1 TXPRECURSOR (See UG482, Table 3-28)</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>5</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_txprecursor</spirit:name>
                     <spirit:description>GT0 TXPRECURSOR (See UG482, Table 3-28)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>5</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000217C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>gt_rx_eq_ctrl</spirit:name>
                  <spirit:description>GTP RX Equalizer Control</spirit:description>
                  <spirit:addressOffset>0x1C</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>gt1_rxlpmlfovrden</spirit:name>
                     <spirit:description>GT1 RXLPMLFOVRDEN (See UG482, Table 4-9)</spirit:description>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_rxlpmlfovrden</spirit:name>
                     <spirit:description>GT0 RXLPMLFOVRDEN (See UG482, Table 4-9)</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_rxlpmlfhold</spirit:name>
                     <spirit:description>GT1 RXLPMLFHOLD (See UG482, Table 4-9)</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_rxlpmlfhold</spirit:name>
                     <spirit:description>GT0 RXLPMLFHOLD (See UG482, Table 4-9)</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_rxlpmhfovrden</spirit:name>
                     <spirit:description>GT1 RXLPMHFOVRDEN (See UG482, Table 4-9)</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_rxlpmhfovrden</spirit:name>
                     <spirit:description>GT0 RXLPMHFOVRDEN (See UG482, Table 4-9)</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_rxlpmhfhold</spirit:name>
                     <spirit:description>GT1 RXLPMHFHOLD (See UG482, Table 4-9)</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_rxlpmhfhold</spirit:name>
                     <spirit:description>GT0 RXLPMHFHOLD (See UG482, Table 4-9)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80002180</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>gt_prbs_ctrl</spirit:name>
                  <spirit:description>GTP Pattern Generator/Receiver Control</spirit:description>
                  <spirit:addressOffset>0x20</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>gt1_rxprbscntreset</spirit:name>
                     <spirit:description>GT1 RXPRBSCNTRESET (Active-High) (See UG482, Table 4-23)</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_rxprbssel</spirit:name>
                     <spirit:description>GT1 RXPRBSSEL (See UG482, Table 4-23)</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>3</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_rxprbscntreset</spirit:name>
                     <spirit:description>GT0 RXPRBSCNTRESET (Active-High) (See UG482, Table 4-23)</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_rxprbssel</spirit:name>
                     <spirit:description>GT0 RXPRBSSEL (See UG482, Table 4-23)</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>3</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_txprbsforceerr</spirit:name>
                     <spirit:description>GT1 TXPRBSFORCEERR (See UG482, Table 3-20)</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_txprbssel</spirit:name>
                     <spirit:description>GT1 TXPRBSSEL (See UG482, Table 3-20)</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>3</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_txprbsforceerr</spirit:name>
                     <spirit:description>GT0 TXPRBSFORCEERR (See UG482, Table 3-20)</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_txprbssel</spirit:name>
                     <spirit:description>GT0 TXPRBSSEL (See UG482, Table 3-20)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>3</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80002184</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>gt_misc_ctrl</spirit:name>
                  <spirit:description>GTP Miscellaneous Control</spirit:description>
                  <spirit:addressOffset>0x24</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>gt1_rxcdrhold</spirit:name>
                     <spirit:description>GT1 RXCDRHOLD (See UG482, Table 4-11)</spirit:description>
                     <spirit:bitOffset>25</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_rxcdrhold</spirit:name>
                     <spirit:description>GT0 RXCDRHOLD (See UG482, Table 4-11)</spirit:description>
                     <spirit:bitOffset>24</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_rxrate</spirit:name>
                     <spirit:description>GT1 RXRATE (See UG482, Table 4-11)</spirit:description>
                     <spirit:bitOffset>20</spirit:bitOffset>
                     <spirit:bitWidth>3</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_rxrate</spirit:name>
                     <spirit:description>GT0 RXRATE (See UG482, Table 4-11)</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>3</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_rxpolarity</spirit:name>
                     <spirit:description>GT1 RXPOLARITY (See UG482, Table 4-22)</spirit:description>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_rxpolarity</spirit:name>
                     <spirit:description>GT0 RXPOLARITY (See UG482, Table 4-22)</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_loopback</spirit:name>
                     <spirit:description>GT1 LOOPBACK (See UG482, Table 2-27)</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>3</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_loopback</spirit:name>
                     <spirit:description>GT0 LOOPBACK (See UG482, Table 2-27)</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>3</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_txpolarity</spirit:name>
                     <spirit:description>GT1 TXPOLARITY (See UG482, Table 3-22)</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_txpolarity</spirit:name>
                     <spirit:description>GT0 TXPOLARITY (See UG482, Table 3-22)</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt1_txinhibit</spirit:name>
                     <spirit:description>GT1 TXINHIBIT (See UG482, Table 3-28)</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>gt0_txinhibit</spirit:name>
                     <spirit:description>GT0 TXINHIBIT (See UG482, Table 3-28)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80002188</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                  <spirit:name>stats0</spirit:name>
                  <spirit:description>All the statistic registers and their configuration.</spirit:description>
                  <spirit:addressOffset>0x28</spirit:addressOffset>
                  <spirit:range>0x18</spirit:range>            
                  <spirit:register>
                     <spirit:name>rd2clr_config</spirit:name>
                     <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>missing_start</spirit:name>
                        <spirit:bitOffset>4</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>gt1_not_in_table</spirit:name>
                        <spirit:bitOffset>3</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>gt1_disp_err</spirit:name>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>gt0_not_in_table</spirit:name>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>gt0_disp_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x8000218C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>gt0_disp_err</spirit:name>
                     <spirit:description>GT0 Disparity Error Count</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>gt0_disp_err</spirit:name>
                        <spirit:description>GT0 RXDISPERR Count (See UG482, Table 4-27)</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80002190</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>gt0_not_in_table</spirit:name>
                     <spirit:description>GT0 Not In Table Count</spirit:description>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>gt0_not_in_table</spirit:name>
                        <spirit:description>GT0 RXNOTINTABLE Count (See UG482, Table 4-27)</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80002194</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>gt1_disp_err</spirit:name>
                     <spirit:description>GT1 Disparity Error Count</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>gt1_disp_err</spirit:name>
                        <spirit:description>GT1 RXDISPERR Count (See UG482, Table 4-27)</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80002198</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>gt1_not_in_table</spirit:name>
                     <spirit:description>GT1 Not In Table Count</spirit:description>
                     <spirit:addressOffset>0x10</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>gt1_not_in_table</spirit:name>
                        <spirit:description>GT1 RXNOTINTABLE Count (See UG482, Table 4-27)</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x8000219C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>missing_start</spirit:name>
                     <spirit:description>Missing Start Control Character Detected</spirit:description>
                     <spirit:addressOffset>0x14</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>missing_start</spirit:name>
                        <spirit:description>Detected an XGMII Idle instead of an XGMII Start control character</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x800021A0</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000218C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 
<spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80002164</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : rxaui  --> 

  <!-- reg group
                    :sl_5g  --> 
          <spirit:registerFile>
               <spirit:name>sl_5g</spirit:name>
               <spirit:description>Single Lane 5G register group</spirit:description>
               <spirit:addressOffset>0x1A4</spirit:addressOffset>
               <spirit:range>0x24</spirit:range>            
               <spirit:register>
                  <spirit:name>gt_rst_ctrl</spirit:name>
                  <spirit:description>GTP Reset Control register</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000011</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>rxbufreset</spirit:name>
                     <spirit:description>RXBUFRESET (Active-High) (See UG482, Table 2-18)</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rxlpmreset</spirit:name>
                     <spirit:description>RXLPMRESET (Active-High) (See UG482, Table 2-18)</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>eyescanreset</spirit:name>
                     <spirit:description>EYESCANRESET (Active-High) (See UG482, Table 2-18)</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rxpmareset</spirit:name>
                     <spirit:description>RXPMARESET (Active-High) (See UG482, Table 2-18)</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rxpcsreset</spirit:name>
                     <spirit:description>RXPCSRESET (Active-High) (See UG482, Table 2-18)</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dont_reset_on_data_error</spirit:name>
                     <spirit:description>Do not automatically reset the RX_STARTUP_FSM of the GTP when DATA_VALID input de-asserts.</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>soft_reset_rx</spirit:name>
                     <spirit:description>Soft Reset of RX path of the GTP (Active-High)
1'b0 - GTP RX Reset FSM is out of reset
1'b1 - GTP RX Reset FSM is in reset
Note: To reset write a 1 followed by a 0</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>txpmareset</spirit:name>
                     <spirit:description>TXPMARESET (Active-High) (See UG482, Table 2-14)</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>txpcsreset</spirit:name>
                     <spirit:description>TXPCSRESET (Active-High) (See UG482, Table 2-14)</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>soft_reset_tx</spirit:name>
                     <spirit:description>Soft Reset of TX path of the GTP (Active-High)
1'b0 - GTP X Reset FSM is out of reset
1'b1 - GTP TX Reset FSM is in reset
Note: To reset write a 1 followed by a 0</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800021A4</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>gt_tx_ctrl</spirit:name>
                  <spirit:description>GTP TX Control</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000043</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>txprbsforceerr</spirit:name>
                     <spirit:description>TXPRBSFORCEERR (Active-High) (See UG482, Table 3-20)</spirit:description>
                     <spirit:bitOffset>27</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>txprbssel</spirit:name>
                     <spirit:description>TXPRBSSEL (See UG482, Table 3-20)</spirit:description>
                     <spirit:bitOffset>24</spirit:bitOffset>
                     <spirit:bitWidth>3</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>txpostcursor</spirit:name>
                     <spirit:description>TXPOSTCURSOR (See UG482, Table 3-28)</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>5</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>txprecursor</spirit:name>
                     <spirit:description>TXPRECURSOR (See UG482, Table 3-28)</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>5</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>txdiffctrl</spirit:name>
                     <spirit:description>TXDIFFCTRL (See UG482, Table 3-28)</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0100</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>txinhibit</spirit:name>
                     <spirit:description>TXINHIBIT (See UG482, Table 3-28)</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>txpolarity</spirit:name>
                     <spirit:description>TXPOLARITY (See UG482, Table 3-22)</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>txpd</spirit:name>
                     <spirit:description>TXPD (See UG482, Table 3-30)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>2</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>11</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800021A8</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>gt_rx_ctrl</spirit:name>
                  <spirit:description>GTP RX Control</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000003</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>rxprbscntreset</spirit:name>
                     <spirit:description>RXPRBSCNTRESET (Active-High) (See UG482, Table 4-23)</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rxprbssel</spirit:name>
                     <spirit:description>RXPRBSSEL (See UG482, Table 4-23)</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>3</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rxlpmlfhold</spirit:name>
                     <spirit:description>RXLPMLFHOLD (See UG482, Table 4-9)</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rxlpmhfovrden</spirit:name>
                     <spirit:description>RXLPMHFOVRDEN (See UG482, Table 4-9)</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rxlpmhfhold</spirit:name>
                     <spirit:description>RXLPMHFHOLD (See UG482, Table 4-9)</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rxcdrhold</spirit:name>
                     <spirit:description>RXCDRHOLD (See UG482, Table 4-11)</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>data_valid_en</spirit:name>
                     <spirit:description>DATA_VALID input to the GT RX_STARTUP_FSM is:
1'b0 : always 1
1'b1 : hardware defined (generally the NOT of the OR of all 8B/10B decode errors)</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rxpolarity</spirit:name>
                     <spirit:description>RXPOLARITY (See UG482, Table 4-22)</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rxpd</spirit:name>
                     <spirit:description>RXPD (See UG482, Table 3-30)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>2</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>11</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800021AC</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>gt_misc_ctrl</spirit:name>
                  <spirit:description>GTP Miscellaneous Control</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>loopback</spirit:name>
                     <spirit:description>LOOPBACK (See UG482, Table 2-27)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>3</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800021B0</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>gt_status</spirit:name>
                  <spirit:description>GTP Status register</spirit:description>
                  <spirit:addressOffset>0x10</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>dmonitorout</spirit:name>
                     <spirit:description>DMONITOROUT[7:0] (See UG482, Table 2-31)</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rxbyteisaligned</spirit:name>
                     <spirit:description>RXBYTEISALIGNED (See UG482, Table 4-25)</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rxbufstatus</spirit:name>
                     <spirit:description>RXBUFSTATUS (See UG482, Table 4-33)</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>3</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rxclkcorcnt</spirit:name>
                     <spirit:description>RXCLKCORCNT (See UG482, Table 4-36)</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>2</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_fsm_reset_done</spirit:name>
                     <spirit:description>RX FSM Reset Done (Active-High)</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_fsm_reset_done</spirit:name>
                     <spirit:description>TX FSM Reset Done (Active-High)</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rxresetdone</spirit:name>
                     <spirit:description>RXRESETDONE (Active-High) (See UG482, Table 2-18)</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>txresetdone</spirit:name>
                     <spirit:description>TXRESETDONE (Active-High) (See UG482, Table 2-14)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800021B4</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                  <spirit:name>stats0</spirit:name>
                  <spirit:description>All the statistic registers and their configuration.</spirit:description>
                  <spirit:addressOffset>0x14</spirit:addressOffset>
                  <spirit:range>0x10</spirit:range>            
                  <spirit:register>
                     <spirit:name>rd2clr_config</spirit:name>
                     <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>gt_rxbyterealign</spirit:name>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>gt_not_in_table</spirit:name>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>gt_disp_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x800021B8</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>gt_disp_err</spirit:name>
                     <spirit:description>GT Disparity Error Count</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>gt_disp_err</spirit:name>
                        <spirit:description>GT RXDISPERR Count (See UG482, Table 4-27)</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x800021BC</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>gt_not_in_table</spirit:name>
                     <spirit:description>GT Not In Table Count</spirit:description>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>gt_not_in_table</spirit:name>
                        <spirit:description>GT RXNOTINTABLE Count (See UG482, Table 4-27)</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x800021C0</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>gt_rxbyterealign</spirit:name>
                     <spirit:description>GT RX Byte Realign Count</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>gt_rxbyterealign</spirit:name>
                        <spirit:description>GT RXBYTEREALIGN Count (See UG482, Table 4-25)</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x800021C4</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800021B8</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 
<spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x800021A4</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : sl_5g  --> 
         <spirit:vendorExtensions>
               <ids_properties>
                  <module_name>bb_top_regs</module_name>
                  <uvm.package>bb_top_regs_pkg</uvm.package>
                  <reset_type>async</reset_type>
                  <cheader.mask_endianess>little</cheader.mask_endianess>
                  <header.struct_guard>__ASSEMBLER__</header.struct_guard>
                  <explicit_name>true</explicit_name>
                  <vertical_reuse>true</vertical_reuse>
                  <address>0x80002000</address>
               </ids_properties>
            </spirit:vendorExtensions>
         </spirit:addressBlock>     
         <spirit:addressBlock>     
            <spirit:name>ge_uart</spirit:name>
            <spirit:description>FIFO-based UART
</spirit:description>  <!-- //
                        block : ge_uart  --> 
            <spirit:baseAddress>0x80002500</spirit:baseAddress>               
            <spirit:range>0x100</spirit:range>               
            <spirit:width>32</spirit:width>            
            <spirit:register>
               <spirit:name>version</spirit:name>
               <spirit:description>Version</spirit:description>
               <spirit:addressOffset>0x0</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00040000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>major</spirit:name>
                  <spirit:description>Major version</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000100</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>minor</spirit:name>
                  <spirit:description>Minor version</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>patch</spirit:name>
                  <spirit:description>Patch version</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80002500</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>tx_fifo</spirit:name>
               <spirit:description>TX FIFO control and status</spirit:description>
               <spirit:addressOffset>0x4</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>fifo_clear</spirit:name>
                  <spirit:description>FIFO clear
</spirit:description>
                  <spirit:bitOffset>31</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                     <ids_properties>
                        <rtl.hw_wp>1</rtl.hw_wp>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_af</spirit:name>
                  <spirit:description>FIFO almost full status field. A 1 indicates an almost full or full FIFO. This bit is set when there are between fifo_aft and fifo_depth number of entries in the FIFO.</spirit:description>
                  <spirit:bitOffset>27</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_ae</spirit:name>
                  <spirit:description>FIFO almost empty status field. A 1 indicates an almost empty or empty FIFO. This bit is set when there are between 0 and fifo_aet number of entries in the FIFO.</spirit:description>
                  <spirit:bitOffset>26</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_full</spirit:name>
                  <spirit:description>FIFO full status field. A 1 indicates a full FIFO.</spirit:description>
                  <spirit:bitOffset>25</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_empty</spirit:name>
                  <spirit:description>FIFO empty status field. A 1 indicates an empty FIFO.</spirit:description>
                  <spirit:bitOffset>24</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_aft</spirit:name>
                  <spirit:description>FIFO almost full threshold</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_aet</spirit:name>
                  <spirit:description>FIFO almost empty threshold</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_depth</spirit:name>
                  <spirit:description>FIFO depth (always 1 byte wide)</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80002504</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>rx_fifo</spirit:name>
               <spirit:description>RX FIFO control and status</spirit:description>
               <spirit:addressOffset>0x8</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>fifo_clear</spirit:name>
                  <spirit:description>FIFO clear
</spirit:description>
                  <spirit:bitOffset>31</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                     <ids_properties>
                        <rtl.hw_wp>1</rtl.hw_wp>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_af</spirit:name>
                  <spirit:description>FIFO almost full status field. A 1 indicates an almost full or full FIFO. This bit is set when there are between fifo_aft and fifo_depth number of entries in the FIFO.</spirit:description>
                  <spirit:bitOffset>27</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_ae</spirit:name>
                  <spirit:description>FIFO almost empty status field. A 1 indicates an almost empty or empty FIFO. This bit is set when there are between 0 and fifo_aet number of entries in the FIFO.</spirit:description>
                  <spirit:bitOffset>26</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_full</spirit:name>
                  <spirit:description>FIFO full status field. A 1 indicates a full FIFO.</spirit:description>
                  <spirit:bitOffset>25</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_empty</spirit:name>
                  <spirit:description>FIFO empty status field. A 1 indicates an empty FIFO.</spirit:description>
                  <spirit:bitOffset>24</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_aft</spirit:name>
                  <spirit:description>FIFO almost full threshold</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_aet</spirit:name>
                  <spirit:description>FIFO almost empty threshold</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>fifo_depth</spirit:name>
                  <spirit:description>FIFO depth (always 1 byte wide)</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80002508</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>tx_data</spirit:name>
               <spirit:description>TX data</spirit:description>
               <spirit:addressOffset>0xC</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>val</spirit:name>
                  <spirit:description>Byte to write into the TX FIFO
</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>write-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                     <ids_properties>
                        <rtl.hw_wp>1</rtl.hw_wp>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x8000250C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>rx_data</spirit:name>
               <spirit:description>RX data</spirit:description>
               <spirit:addressOffset>0x10</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>val</spirit:name>
                  <spirit:description>Byte to read from the RX FIFO
</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                     <ids_properties>
                        <rtl.hw_rp>1</rtl.hw_rp>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80002510</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>control</spirit:name>
               <spirit:description>Control</spirit:description>
               <spirit:addressOffset>0x14</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>prescaler</spirit:name>
                  <spirit:description>Prescaler reload value
round(module clock frequency / baud rate)</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>16</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0000000000000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>tx_irq_en</spirit:name>
                  <spirit:description>Transmitter interrupt enable</spirit:description>
                  <spirit:bitOffset>3</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>rx_irq_en</spirit:name>
                  <spirit:description>Receiver interrupt enable</spirit:description>
                  <spirit:bitOffset>2</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>tx_en</spirit:name>
                  <spirit:description>Transmitter enable</spirit:description>
                  <spirit:bitOffset>1</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>rx_en</spirit:name>
                  <spirit:description>Receiver enable</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80002514</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>timeout</spirit:name>
               <spirit:description>Timeout</spirit:description>
               <spirit:addressOffset>0x18</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>val</spirit:name>
                  <spirit:description>&gt; 0: If no character was received within this number of module clock cycles and RX FIFO is not empty RX IRQ will be asserted. If a new character is received before timer expiry or when the timer is expired, the timer is reset and restarted.
0: Disables the timeout functionality</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>32</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000000000000000000000000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80002518</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>errors</spirit:name>
               <spirit:description>Errors - Write 1 to clear</spirit:description>
               <spirit:addressOffset>0x1C</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>overrun_err</spirit:name>
                  <spirit:description>Overrun Error:
If this is 1 the RX FIFO was full and a received character had to be discarded</spirit:description>
                  <spirit:bitOffset>2</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>stop_err</spirit:name>
                  <spirit:description>Stop Error:
If this is 1 a character was received but a 0 was seen in the middle of what was expected to be the stop bit; this condition does not impact how the received character is treated</spirit:description>
                  <spirit:bitOffset>1</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>start_err</spirit:name>
                  <spirit:description>Start Error:
A falling edge on the UART RX line was detected but before reaching the middle of the start bit a 1 was seen; this condition does not impact how the received character is treated</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x8000251C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>         
            <spirit:vendorExtensions>
               <ids_properties>
                  <module_name>uart_regs</module_name>
                  <uvm.package>uart_regs_pkg</uvm.package>
                  <reset_type>async</reset_type>
                  <cheader.mask_endianess>little</cheader.mask_endianess>
                  <header.struct_guard>__ASSEMBLER__</header.struct_guard>
                  <explicit_name>true</explicit_name>
                  <vertical_reuse>true</vertical_reuse>
                  <address>0x80002500</address>
               </ids_properties>
            </spirit:vendorExtensions>
         </spirit:addressBlock>     
         <spirit:addressBlock>     
            <spirit:name>link_layer_tx</spirit:name>
            <spirit:description>Link Layer TX Registers
</spirit:description>  <!-- //
                        block : link_layer_tx  --> 
            <spirit:baseAddress>0x80003000</spirit:baseAddress>               
            <spirit:range>0x200</spirit:range>               
            <spirit:width>32</spirit:width>            
            <spirit:register>
               <spirit:name>version</spirit:name>
               <spirit:description>5.1.0: Added registers to disable/enable CRC32. And also to inject CRC32 errors
5.2.0: Changed the Interrupt Pending to avoid blocking the register update when enable is 0
5.3.0: Added pending_irq register
5.4.0: Changed Logic to Wire in ift_xgmii and ift_gmii</spirit:description>
               <spirit:addressOffset>0x0</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00050400</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>major</spirit:name>
                  <spirit:description>Major version</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000101</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>minor</spirit:name>
                  <spirit:description>Minor version</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000100</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>patch</spirit:name>
                  <spirit:description>Patch version</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80003000</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>
  <!-- reg group
                    :mac  --> 
          <spirit:registerFile>
               <spirit:name>mac</spirit:name>
               <spirit:addressOffset>0x4</spirit:addressOffset>
               <spirit:range>0x5C</spirit:range>            
               <spirit:register>
                  <spirit:name>version</spirit:name>
                  <spirit:description>2.1.0: Added registers to disable/enable CRC32. And also to inject CRC32 errors</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00020100</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>major</spirit:name>
                     <spirit:description>Major version</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000010</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>minor</spirit:name>
                     <spirit:description>Minor version</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000001</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>patch</spirit:name>
                     <spirit:description>Patch version</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003004</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>mac_config</spirit:name>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>inject_crc32_err</spirit:name>
                     <spirit:description>Assert high to ask the logic to insert one crc32 error when CRC32 logic is implemented.

Write a 1 and HW clears it when completed the action
</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <rtl.hw_clear>true</rtl.hw_clear>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>disable_crc32</spirit:name>
                     <spirit:description>When set to 1, and if the CRC32 logic is implemented, disables inclusion of correct CRC32.</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>crc32_implmntd</spirit:name>
                     <spirit:description>This is the synthesis parameter value used for CRC32 logic implementation. When 1, it shows the CRC32 logic has been implemented in the logic. Note that, typically CRC32 MUST be implemented in MAC. However, due to some timing issues, we may decide to not have the logic when the system is used in a point-to-point configuration.</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dbg_seq_num_en</spirit:name>
                     <spirit:description>When set to 1 it enables the debug logic to insert consecutive sequence numbers in the frame. 

Typically, this and the corresponding register in the RX path should be configured before any traffic sent between the TX and RX. Otherwise, there will not be synchrony between the sent and expected sequence numbers for at least one time</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>en</spirit:name>
                     <spirit:description>When set to 1 it enables the block. NOT USED.</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003008</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pa_word1</spirit:name>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00555555</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>pa_word1</spirit:name>
                     <spirit:description>Preamble values (upper 3 bytes)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>24</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>010101010101010101010101</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000300C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pa_word0</spirit:name>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x55555555</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>pa_word0</spirit:name>
                     <spirit:description>Preamble values (lower 4 bytes)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>32</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>01010101010101010101010101010101</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003010</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>sfd</spirit:name>
                  <spirit:addressOffset>0x10</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x000000D5</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>sfd</spirit:name>
                     <spirit:description>The Start of Frame Delimiter (SFD)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>11010101</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003014</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>da_word1</spirit:name>
                  <spirit:description>Destination Address Word1</spirit:description>
                  <spirit:addressOffset>0x14</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x0000DADA</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>da_w1</spirit:name>
                     <spirit:description>This is the MAC Destination address (upper 2 bytes [47:32])</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1101101011011010</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003018</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>da_word0</spirit:name>
                  <spirit:description>Destination Address Word0</spirit:description>
                  <spirit:addressOffset>0x18</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0xDADADADA</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>da_w0</spirit:name>
                     <spirit:description>This is the MAC Destination address (lower 4 bytes [31:0])</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>32</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>11011010110110101101101011011010</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000301C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>sa__word1</spirit:name>
                  <spirit:description>Source Address Word1</spirit:description>
                  <spirit:addressOffset>0x1C</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00005A5A</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>sa_w1</spirit:name>
                     <spirit:description>This is the MAC Source address (upper 2 bytes [47:32])</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0101101001011010</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003020</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>sa_word0</spirit:name>
                  <spirit:description>Source Address Word0</spirit:description>
                  <spirit:addressOffset>0x20</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x5A5A5A5A</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>sa_w0</spirit:name>
                     <spirit:description>This is the MAC Source address (lower 4 bytes [31:0])</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>32</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>01011010010110100101101001011010</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003024</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>lt</spirit:name>
                  <spirit:description>Length/Type Filter</spirit:description>
                  <spirit:addressOffset>0x24</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00001717</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>lt_mode</spirit:name>
                     <spirit:description>When 0: The LT field is to be the Length of the payload
When 1: The LT field is to be the Type of the payload</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lt</spirit:name>
                     <spirit:description>This is the MAC type</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0001011100010111</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003028</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>idle</spirit:name>
                  <spirit:addressOffset>0x28</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x0000001E</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>idle</spirit:name>
                     <spirit:description>Idle character</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00011110</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000302C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>frm_rate</spirit:name>
                  <spirit:description>The extra gap (in addition to the mandatory gap) between each Ethernet frame allowing a fine control of the data throughput on the link.</spirit:description>
                  <spirit:addressOffset>0x2C</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>frm_rate</spirit:name>
                     <spirit:description>This is the number of idle clock cycles inserted between the frames. For each implementation, it will add frm_rate*bus_size number of MAC bits.</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>12</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003030</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>bandwidth_gap</spirit:name>
                  <spirit:description>This is the number of idle clock cycles inserted after a specified number of data words (equal to the clock cycles that has data) are reached. For each implementation, it will add bandwidth_gap*bus_size number of MAC bits.</spirit:description>
                  <spirit:addressOffset>0x30</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>bandwidth_gap</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>32</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000000000000000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003034</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>bandwidth_limit</spirit:name>
                  <spirit:description>This is the number of data words (equal to the clock cycles that has data) that needs to be reached before Bandwidth Gap can be inserted.</spirit:description>
                  <spirit:addressOffset>0x34</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>bandwidth_limit</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>32</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000000000000000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003038</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                  <spirit:name>stats0</spirit:name>
                  <spirit:description>All the Statistic Registers and their configuration.</spirit:description>
                  <spirit:addressOffset>0x38</spirit:addressOffset>
                  <spirit:range>0x24</spirit:range>            
                  <spirit:register>
                     <spirit:name>rd2clr_config</spirit:name>
                     <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>fsm_rollover</spirit:name>
                        <spirit:bitOffset>7</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>fsm_count_beyond_ptp</spirit:name>
                        <spirit:bitOffset>6</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>in_sop</spirit:name>
                        <spirit:bitOffset>5</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>in_eop</spirit:name>
                        <spirit:bitOffset>4</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>stall_ptp_in</spirit:name>
                        <spirit:bitOffset>3</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>out_sop</spirit:name>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>out_eop</spirit:name>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>pause_frame</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x8000303C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>pause_frame</spirit:name>
                     <spirit:description>Count of pause frames transmitted</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>pause_frame</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003040</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>out_eop</spirit:name>
                     <spirit:description>Count of the PTP EOP seen on the output port to the RS</spirit:description>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>out_eop</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003044</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>out_sop</spirit:name>
                     <spirit:description>Count of the PTP SOP seen on the output port to the RS</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>out_sop</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003048</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>stall_ptp_in</spirit:name>
                     <spirit:description>Count of cycles the MAC input is stalled</spirit:description>
                     <spirit:addressOffset>0x10</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>stall_ptp_in</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x8000304C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>in_eop</spirit:name>
                     <spirit:description>Count of the EOP of the PTP packets seen from the clients and after the input stall logic</spirit:description>
                     <spirit:addressOffset>0x14</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>in_eop</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003050</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>in_sop</spirit:name>
                     <spirit:description>Count of the EOP of the PTP packets seen from the clients and after the input stall logic</spirit:description>
                     <spirit:addressOffset>0x18</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>in_sop</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003054</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>fsm_count_beyond_ptp</spirit:name>
                     <spirit:description>Count of the number of cycles the FSM has been beyond the permissible maximum value. This indicates an error in the function of this block</spirit:description>
                     <spirit:addressOffset>0x1C</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>fsm_count_beyond_ptp</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80003058</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>fsm_rollover</spirit:name>
                     <spirit:description>Count of the number of times the input FSM rolled over. This indicates an error in the function of this block</spirit:description>
                     <spirit:addressOffset>0x20</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>fsm_rollover</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x8000305C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000303C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 
<spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80003004</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : mac  --> 

  <!-- reg group
                    :media_rs  --> 
          <spirit:registerFile>
               <spirit:name>media_rs</spirit:name>
               <spirit:description>Registers needed for the Media RS in the TX Path</spirit:description>
               <spirit:addressOffset>0x60</spirit:addressOffset>
               <spirit:range>0x8C</spirit:range>            
               <spirit:register>
                  <spirit:name>version</spirit:name>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00010000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>major</spirit:name>
                     <spirit:description>Major version</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000001</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>minor</spirit:name>
                     <spirit:description>Minor version</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>patch</spirit:name>
                     <spirit:description>Patch version</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003060</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>enable</spirit:name>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000001</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>tx_xgmii_en</spirit:name>
                     <spirit:description>When 1, and tx_xgmii_en is 0, it enables the XGMII path</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tx_gmii_en</spirit:name>
                     <spirit:description>When 1, and tx_xgmii_en is 0, it enables the GMII path</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003064</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
  <!-- reg group
                    :pfifo  --> 
          <spirit:registerFile>
                  <spirit:name>pfifo</spirit:name>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:range>0x50</spirit:range>            
                  <spirit:register>
                     <spirit:name>version</spirit:name>
                     <spirit:description>Version 1.1.0: Added Icron Attributes for stats script generation</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:reset>
                        <spirit:value>0x00010100</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>major</spirit:name>
                        <spirit:description>Major version</spirit:description>
                        <spirit:bitOffset>16</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000001</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>minor</spirit:name>
                        <spirit:description>Minor version</spirit:description>
                        <spirit:bitOffset>8</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000001</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>patch</spirit:name>
                        <spirit:description>Patch version</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003068</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
  <!-- reg group
                    :write_engine  --> 
          <spirit:registerFile>
                     <spirit:name>write_engine</spirit:name>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:range>0x38</spirit:range>
  <!-- reg group
                    :config0  --> 
          <spirit:registerFile>
                        <spirit:name>config0</spirit:name>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:range>0xC</spirit:range>            
                        <spirit:register>
                           <spirit:name>clear</spirit:name>
                           <spirit:description>Synchronous clear for the write clock domain</spirit:description>
                           <spirit:addressOffset>0x0</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>wclr</spirit:name>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <address>0x8000306C</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>mode</spirit:name>
                           <spirit:addressOffset>0x4</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000005</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>drp_on_sop</spirit:name>
                              <spirit:description>When set, drops the current packet without writing it to the buffer. See Wiki</spirit:description>
                              <spirit:bitOffset>3</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>drp_on_pkt_err</spirit:name>
                              <spirit:description>When set, removes the packet from the buffer without presenting it to the output interface upon the ERR bit being set before the notification point. See Wiki</spirit:description>
                              <spirit:bitOffset>2</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>1</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>pkt_strm</spirit:name>
                              <spirit:description>Selects packet based or streaming based behavior. See Wiki</spirit:description>
                              <spirit:bitOffset>1</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>flw_ctrl_en</spirit:name>
                              <spirit:description>Enables the flow control. See Wiki</spirit:description>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>1</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <address>0x80003070</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>notify_limit</spirit:name>
                           <spirit:addressOffset>0x8</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>ntfy_lmt</spirit:name>
                              <spirit:description>Sets the number of words required to be written into the packet FIFO before a notification will be generated. See wiki</spirit:description>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>32</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>00000000000000000000000000000000</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <address>0x80003074</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x8000306C</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:registerFile>  <!-- end
                of reg group : config0  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                        <spirit:name>stats0</spirit:name>
                        <spirit:description>All the Statistic Registers and their configuration for the Write Engine</spirit:description>
                        <spirit:addressOffset>0xC</spirit:addressOffset>
                        <spirit:range>0x2C</spirit:range>            
                        <spirit:register>
                           <spirit:name>rd2clr_config</spirit:name>
                           <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                           <spirit:addressOffset>0x0</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>flow_ctrl</spirit:name>
                              <spirit:bitOffset>9</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>drp_pkt_wr</spirit:name>
                              <spirit:bitOffset>8</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>drp_pkt_rd</spirit:name>
                              <spirit:bitOffset>7</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>wflush_act</spirit:name>
                              <spirit:bitOffset>6</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>pkt_sop_err</spirit:name>
                              <spirit:bitOffset>5</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>pkt_err</spirit:name>
                              <spirit:bitOffset>4</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>fifo_full_err</spirit:name>
                              <spirit:bitOffset>3</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>pkt_max_byte_cnt_err</spirit:name>
                              <spirit:bitOffset>2</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>pfifo_dcount</spirit:name>
                              <spirit:bitOffset>1</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:field>
                              <spirit:name>nfifo_dcount</spirit:name>
                              <spirit:bitOffset>0</spirit:bitOffset>
                              <spirit:bitWidth>1</spirit:bitWidth>
                              <spirit:volatile>false</spirit:volatile>
                              <spirit:access>read-write</spirit:access>
                              <spirit:vendorExtensions>
                                 <ids:default_value>0</ids:default_value>
                              </spirit:vendorExtensions>
                           </spirit:field>
                           <spirit:vendorExtensions>
                              <ids_properties>
                                 <external>true</external>
                                 <address>0x80003078</address>
                              </ids_properties>
                           </spirit:vendorExtensions>
                        </spirit:register>            
                        <spirit:register>
                           <spirit:name>nfifo_dcount</spirit:name>
                           <spirit:description>Current level for the notification FIFO in the PFIFO</spirit:description>
                           <spirit:addressOffset>0x4</spirit:addressOffset>
                           <spirit:size>32</spirit:size>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:reset>
                              <spirit:value>0x00000000</spirit:value>
                              <spirit:mask>0xFFFFFFFF</spirit:mask>
                           </spirit:reset>
                           <spirit:field>
                              <spirit:name>nfifo_dcount</spirit:name>
                              <spirit:description>_icron_water_marker_
