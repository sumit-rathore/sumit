                              <address>0x80003EF4</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>err_count</spirit:name>
                        <spirit:description>Receive error count</spirit:description>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>err_count</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>32</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000000000000000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80003EF8</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pkt_count</spirit:name>
                        <spirit:description>Receive packet count</spirit:description>
                        <spirit:addressOffset>0x8</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>pkt_count</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>32</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000000000000000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80003EFC</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80003EF4</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 
<spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80003EEC</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : rx  --> 
<spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80003EC8</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : test_mode  --> 
         <spirit:vendorExtensions>
               <ids_properties>
                  <module_name>mca_channel_regs</module_name>
                  <uvm.package>mca_channel_regs_pkg</uvm.package>
                  <reset_type>async</reset_type>
                  <cheader.mask_endianess>little</cheader.mask_endianess>
                  <header.struct_guard>__ASSEMBLER__</header.struct_guard>
                  <explicit_name>true</explicit_name>
                  <vertical_reuse>true</vertical_reuse>
                  <repeat>6</repeat>
                  <address>0x80003E00</address>
               </ids_properties>
            </spirit:vendorExtensions>
         </spirit:addressBlock>     
         <spirit:addressBlock>     
            <spirit:name>dp_sink_main</spirit:name>
            <spirit:description>DP Sink
</spirit:description>  <!-- //
                        block : dp_sink_main  --> 
            <spirit:baseAddress>0x80004400</spirit:baseAddress>               
            <spirit:range>0x200</spirit:range>               
            <spirit:width>32</spirit:width>            
            <spirit:register>
               <spirit:name>version</spirit:name>
               <spirit:description>Version</spirit:description>
               <spirit:addressOffset>0x0</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00080900</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>major</spirit:name>
                  <spirit:description>Major version</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00001000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>minor</spirit:name>
                  <spirit:description>Minor version</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00001001</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>patch</spirit:name>
                  <spirit:description>Patch version</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004400</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>configuration</spirit:name>
               <spirit:description>General configuration</spirit:description>
               <spirit:addressOffset>0x4</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x0000003B</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>debug_msa_en</spirit:name>
                  <spirit:description>Enable debug MSA registers</spirit:description>
                  <spirit:bitOffset>31</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>tu_measured</spirit:name>
                  <spirit:description>tu_measured signal status</spirit:description>
                  <spirit:bitOffset>17</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>tico_ctrl_rst</spirit:name>
                  <spirit:description>Tico Encoder ctrl_rst pin status</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>vid_color_format</spirit:name>
                  <spirit:description>DP video color format
2'b00: RGB888
2'b01: YCbCr444
2'b10: YCbCr422
2'b11: YCbCr420</spirit:description>
                  <spirit:bitOffset>14</spirit:bitOffset>
                  <spirit:bitWidth>2</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>vid_bit_per_component</spirit:name>
                  <spirit:description>DP video bits per component
3'b000: 6
3'b001: 8
3'b010: 10
3'b011: 12
3'b100: 16</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>3</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>vid_stream_extractor_en</spirit:name>
                  <spirit:description>Enable video related stream_extractor module</spirit:description>
                  <spirit:bitOffset>7</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>stream_extractor_en</spirit:name>
                  <spirit:description>Enable stream_extractor module</spirit:description>
                  <spirit:bitOffset>6</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>apb_to_axi_mode_select</spirit:name>
                  <spirit:description>APB to AXI read mode select
1'b1: The read cycle is at least one clock later than read address cycle
1'b0: The read cycle happens at the same cycle as read address cycle</spirit:description>
                  <spirit:bitOffset>5</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>1</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>enh_frm_en</spirit:name>
                  <spirit:description>DP enhanced framing mode enable. The enhanced mode is enabled when this bit is set to 1.</spirit:description>
                  <spirit:bitOffset>4</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>1</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>lane_bit_rate</spirit:name>
                  <spirit:description>DP serial bit rate
2'b00: RBR (1.62 Gbps)
2'b01: HBR (2.70 Gbps)
2'b10: HBR2 (5.40 Gbps)
2'b11: HBR3(8.10 Gbps)</spirit:description>
                  <spirit:bitOffset>2</spirit:bitOffset>
                  <spirit:bitWidth>2</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>10</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>lane_num</spirit:name>
                  <spirit:description>Number of active dp lanes
2'b00: 1 lane
2'b01: 2 lanes
2'b10: Invalid
2'b11: 4 lanes</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>2</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>11</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004404</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>
  <!-- reg group
                    :aligner  --> 
          <spirit:registerFile>
               <spirit:name>aligner</spirit:name>
               <spirit:description>Aligner module registers</spirit:description>
               <spirit:addressOffset>0x8</spirit:addressOffset>
               <spirit:range>0x24</spirit:range>            
               <spirit:register>
                  <spirit:name>control</spirit:name>
                  <spirit:description>Aligner module control register</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>tps3_n_tps2</spirit:name>
                     <spirit:description>Test pattern selection
1'b0: TPS2
1'b1: TPS3</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>align_en</spirit:name>
                     <spirit:description>Align module enable
1'b0: Disable
1'b1: Enable</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004408</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>status</spirit:name>
                  <spirit:description>Aligner module bond/align status register</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>lanes_not_aligned</spirit:name>
                     <spirit:description>Alignment is not correct even though bond_align_done is set to high</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>bond_align_done</spirit:name>
                     <spirit:description>Alignment and bonding status. A "1" indicates all active lanes are bonded and aligned</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000440C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>stats</spirit:name>
                  <spirit:description>Aligner lanes not aligned</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>lanes_not_aligned_cnt</spirit:name>
                     <spirit:description>Number of clock cycles where lanes are not aligned after detection is enabled</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lanes_not_aligned_cnt_rst</spirit:name>
                     <spirit:description>Align detector logic enable
1'b0: Disable
1'b1: Enable</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lanes_align_det_en</spirit:name>
                     <spirit:description>Align detector logic enable
1'b0: Disable
1'b1: Enable</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004410</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
  <!-- reg group
                    :debug  --> 
          <spirit:registerFile>
                  <spirit:name>debug</spirit:name>
                  <spirit:description>Aligner debug stats</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:range>0x10</spirit:range>            
                  <spirit:register>
                     <spirit:name>stats1</spirit:name>
                     <spirit:description>Aligner FSM</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>state_dbg</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004414</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>stats2</spirit:name>
                     <spirit:description>Aligner FIFO read enables</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>fifo_rd_en_dbg</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004418</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>stats3</spirit:name>
                     <spirit:description>Aligner comma detect</spirit:description>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>com_det_dbg</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>32</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x8000441C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>stats4</spirit:name>
                     <spirit:description>Aligner debug data</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>bond_align_debug_stats</spirit:name>
                        <spirit:description>Several stats for debugging</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>24</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004420</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004414</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : debug  --> 
            <spirit:register>
                  <spirit:name>fifo_status</spirit:name>
                  <spirit:description>Aligner module FIFO status register</spirit:description>
                  <spirit:addressOffset>0x1C</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x0000000F</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>overflow</spirit:name>
                     <spirit:description>FIFO overflow status. A "1" indicates overflow in FIFO.

Bit[12] corresponds to lane 0 FIFO
Bit[13] corresponds to lane 1 FIFO
Bit[14] corresponds to lane 2 FIFO
Bit[15] corresponds to lane 3 FIFO</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>underflow</spirit:name>
                     <spirit:description>FIFO underflow status. A "1" indicates underflow in FIFO.

Bit[8] corresponds to lane 0 FIFO
Bit[9] corresponds to lane 1 FIFO
Bit[10] corresponds to lane 2 FIFO
Bit[11] corresponds to lane 3 FIFO</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>full</spirit:name>
                     <spirit:description>FIFO full status. A "1" indicates FIFO is full

Bit[4] corresponds to lane 0 FIFO
Bit[5] corresponds to lane 1 FIFO
Bit[6] corresponds to lane 2 FIFO
Bit[7] corresponds to lane 3 FIFO</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>empty</spirit:name>
                     <spirit:description>FIFO empty status. A "1" indicates FIFO is empty

Bit[0] corresponds to lane 0 FIFO
Bit[1] corresponds to lane 1 FIFO
Bit[2] corresponds to lane 2 FIFO
Bit[3] corresponds to lane 3 FIFO</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1111</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004424</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_config</spirit:name>
                  <spirit:description>Aligner depth</spirit:description>
                  <spirit:addressOffset>0x20</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>depth</spirit:name>
                     <spirit:description>FIFO depth. This value is used for the build</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004428</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004408</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : aligner  --> 

  <!-- reg group
                    :stats  --> 
          <spirit:registerFile>
               <spirit:name>stats</spirit:name>
               <spirit:description>8b10b and gtp debug stats</spirit:description>
               <spirit:addressOffset>0x2C</spirit:addressOffset>
               <spirit:range>0x1C</spirit:range>            
               <spirit:register>
                  <spirit:name>flag_8b10b</spirit:name>
                  <spirit:description>8b10b error flag</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>lanes_with_8b10b_nit_err_post_cr</spirit:name>
                     <spirit:description>There are 8b10b not in table decoder errors</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lanes_with_8b10b_dis_err_post_cr</spirit:name>
                     <spirit:description>There are 8b10b disparity decoder errors</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000442C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>cnt_en_rst_8b10b_0</spirit:name>
                  <spirit:description>8b10b disparity error counts reset</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>lane3_8b10b_dis_err_post_cr_cnt_rst</spirit:name>
                     <spirit:description>8b10b disparity error reset on lane 3</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lane2_8b10b_dis_err_post_cr_cnt_rst</spirit:name>
                     <spirit:description>8b10b disparity error reset on lane 2</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lane1_8b10b_dis_err_post_cr_cnt_rst</spirit:name>
                     <spirit:description>8b10b disparity error reset on lane 1</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lane0_8b10b_dis_err_post_cr_cnt_rst</spirit:name>
                     <spirit:description>8b10b disparity error reset on lane 0</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lanes_8b10b_dis_err_det_en</spirit:name>
                     <spirit:description>8b10b disparity error detector enable</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004430</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>cnt_en_rst_8b10b_1</spirit:name>
                  <spirit:description>8b10b not in table error counts reset</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>lane3_8b10b_nit_err_post_cr_cnt_rst</spirit:name>
                     <spirit:description>8b10b not in table error reset on lane 3</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lane2_8b10b_nit_err_post_cr_cnt_rst</spirit:name>
                     <spirit:description>8b10b not in table error reset on lane 2</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lane1_8b10b_nit_err_post_cr_cnt_rst</spirit:name>
                     <spirit:description>8b10b not in table error reset on lane 1</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lane0_8b10b_nit_err_post_cr_cnt_rst</spirit:name>
                     <spirit:description>8b10b not in table error reset on lane 0</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lanes_8b10b_nit_err_det_en</spirit:name>
                     <spirit:description>8b10b not in table error detector enable</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004434</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>cnt_8b10b_0</spirit:name>
                  <spirit:description>8b10b disparity error counts</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>lane3_8b10b_dis_err_post_cr_cnt</spirit:name>
                     <spirit:description>Number of 8b10b disparity errors on lane 3</spirit:description>
                     <spirit:bitOffset>24</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lane2_8b10b_dis_err_post_cr_cnt</spirit:name>
                     <spirit:description>Number of 8b10b disparity errors on lane 2</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lane1_8b10b_dis_err_post_cr_cnt</spirit:name>
                     <spirit:description>Number of 8b10b disparity errors on lane 1</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lane0_8b10b_dis_err_post_cr_cnt</spirit:name>
                     <spirit:description>Number of 8b10b disparity errors on lane 0</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004438</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>cnt_8b10b_1</spirit:name>
                  <spirit:description>8b10b not in table error counts</spirit:description>
                  <spirit:addressOffset>0x10</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>lane3_8b10b_nit_err_post_cr_cnt</spirit:name>
                     <spirit:description>Number of 8b10b not in table errors on lane 3</spirit:description>
                     <spirit:bitOffset>24</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lane2_8b10b_nit_err_post_cr_cnt</spirit:name>
                     <spirit:description>Number of 8b10b not in table errors on lane 2</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lane1_8b10b_nit_err_post_cr_cnt</spirit:name>
                     <spirit:description>Number of 8b10b not in table errors on lane 1</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lane0_8b10b_nit_err_post_cr_cnt</spirit:name>
                     <spirit:description>Number of 8b10b not in table errors on lane 0</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000443C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>cnt_en_rst_gtp</spirit:name>
                  <spirit:description>GTP realign counts</spirit:description>
                  <spirit:addressOffset>0x14</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>dp_gt_rxbyterealign_cnt_rst</spirit:name>
                     <spirit:description>Reset the rxbytealign counters</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_gt_rxbyterealign_cnt_en</spirit:name>
                     <spirit:description>Enable the rxbyterealign counters</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004440</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>cnt_gtp</spirit:name>
                  <spirit:description>GTP realign counts</spirit:description>
                  <spirit:addressOffset>0x18</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>dp_gt3_rxbyterealign_cnt</spirit:name>
                     <spirit:description>Number of clock cycles where gt3 symbol is realigned</spirit:description>
                     <spirit:bitOffset>24</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_gt2_rxbyterealign_cnt</spirit:name>
                     <spirit:description>Number of clock cycles where gt2 symbol is realigned</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_gt1_rxbyterealign_cnt</spirit:name>
                     <spirit:description>Number of clock cycles where gt1 symbol is realigned</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_gt0_rxbyterealign_cnt</spirit:name>
                     <spirit:description>Number of clock cycles where gt0 symbol is realigned</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004444</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x8000442C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : stats  --> 
            <spirit:register>
               <spirit:name>descrambler</spirit:name>
               <spirit:addressOffset>0x48</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>enable</spirit:name>
                  <spirit:description>Descrambler enable bit. The descrambler is enabled when this bit is set to 1. It is bypassed when this bit is set to 0.</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004448</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>
  <!-- reg group
                    :stream_extractor  --> 
          <spirit:registerFile>
               <spirit:name>stream_extractor</spirit:name>
               <spirit:addressOffset>0x4C</spirit:addressOffset>
               <spirit:range>0x74</spirit:range>            
               <spirit:register>
                  <spirit:name>cfg</spirit:name>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00030168</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>sdp_en</spirit:name>
                     <spirit:description>Enable SDP</spirit:description>
                     <spirit:bitOffset>24</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>drop_sdp_ptp_pkt</spirit:name>
                     <spirit:description>Drop SDP packets going to MCA</spirit:description>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>drop_cs_ptp_pkt</spirit:name>
                     <spirit:description>Drop CS packets going to MCA</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>cs_pkt_length</spirit:name>
                     <spirit:description>Compressed video packet length</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>12</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000101101000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000444C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>alu</spirit:name>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000040</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>encoder_program_done</spirit:name>
                     <spirit:description>Encoder programming is completed</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <rtl.hw_clear>1</rtl.hw_clear>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tu_size</spirit:name>
                     <spirit:description>TU size receved from host</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>01000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004450</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
  <!-- reg group
                    :msa  --> 
          <spirit:registerFile>
                  <spirit:name>msa</spirit:name>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:range>0x24</spirit:range>            
                  <spirit:register>
                     <spirit:name>mvid</spirit:name>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>mvid</spirit:name>
                        <spirit:description>msa mvid value</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>24</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004454</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>nvid</spirit:name>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>nvid</spirit:name>
                        <spirit:description>msa nvid value</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>24</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004458</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>horizontal_0</spirit:name>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>total</spirit:name>
                        <spirit:description>msa h total</spirit:description>
                        <spirit:bitOffset>16</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>start</spirit:name>
                        <spirit:description>msa h start</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x8000445C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>horizontal_1</spirit:name>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>width</spirit:name>
                        <spirit:description>msa h width</spirit:description>
                        <spirit:bitOffset>16</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>polarity</spirit:name>
                        <spirit:description>msa h sync polarity (hsp)</spirit:description>
                        <spirit:bitOffset>15</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>sync_width</spirit:name>
                        <spirit:description>msa h sync width (hsw)</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>15</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004460</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>vertical_0</spirit:name>
                     <spirit:addressOffset>0x10</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>total</spirit:name>
                        <spirit:description>msa v total</spirit:description>
                        <spirit:bitOffset>16</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>start</spirit:name>
                        <spirit:description>msa v start</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004464</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>vertical_1</spirit:name>
                     <spirit:addressOffset>0x14</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>height</spirit:name>
                        <spirit:description>msa v height</spirit:description>
                        <spirit:bitOffset>16</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>polarity</spirit:name>
                        <spirit:description>msa v sync polarity (vsp)</spirit:description>
                        <spirit:bitOffset>15</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>sync_width</spirit:name>
                        <spirit:description>msa v sync width (vsw)</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>15</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004468</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>misc</spirit:name>
                     <spirit:addressOffset>0x18</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>y_only</spirit:name>
                        <spirit:description>msa misc_1 bit 7 field for Y-only video</spirit:description>
                        <spirit:bitOffset>11</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>stereo</spirit:name>
                        <spirit:description>msa misc_1 bits 2:1 field for Stereo video attribute
0 = No 3D video</spirit:description>
                        <spirit:bitOffset>9</spirit:bitOffset>
                        <spirit:bitWidth>2</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>int_total</spirit:name>
                        <spirit:description>msa misc_1 bit 0 field for interlaced video</spirit:description>
                        <spirit:bitOffset>8</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>color</spirit:name>
                        <spirit:description>msa misc_0 bits 7:1 for the Colorimetry field
See DP 1.2 page 78
0x00 = RGB 18bpp
0x10 = RGB 24bpp
0x20 = RGB 30bpp
0x30 = RGB 36bpp
0x40 = RGB 48bpp</spirit:description>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>7</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>clk_sync</spirit:name>
                        <spirit:description>msa misc_0 bit 0 for synchronous clock.
0 = Link and main video clock are asynchronous
1 = Link and main video clock are synchronous</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x8000446C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>status</spirit:name>
                     <spirit:description>Stream_extractor module status register</spirit:description>
                     <spirit:addressOffset>0x1C</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>msa_majority_fail</spirit:name>
                        <spirit:description>MSA majority rule status. A "1" indicates that the majority rule failed</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004470</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>fps</spirit:name>
                     <spirit:addressOffset>0x20</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>count</spirit:name>
                        <spirit:description>Frame counter</spirit:description>
                        <spirit:bitOffset>8</spirit:bitOffset>
                        <spirit:bitWidth>24</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>count_en</spirit:name>
                        <spirit:description>Frame counter enable</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004474</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004454</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : msa  --> 

  <!-- reg group
                    :debug_msa  --> 
          <spirit:registerFile>
                  <spirit:name>debug_msa</spirit:name>
                  <spirit:addressOffset>0x2C</spirit:addressOffset>
                  <spirit:range>0x1C</spirit:range>            
                  <spirit:register>
                     <spirit:name>mvid</spirit:name>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>mvid</spirit:name>
                        <spirit:description>msa mvid value</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>24</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004478</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>nvid</spirit:name>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>nvid</spirit:name>
                        <spirit:description>msa nvid value</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>24</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x8000447C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>horizontal_0</spirit:name>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x0FA00036</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>total</spirit:name>
                        <spirit:description>msa h total</spirit:description>
                        <spirit:bitOffset>16</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000111110100000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>start</spirit:name>
                        <spirit:description>msa h start</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000110110</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004480</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>horizontal_1</spirit:name>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x0F000020</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>width</spirit:name>
                        <spirit:description>msa h width</spirit:description>
                        <spirit:bitOffset>16</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000111100000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>polarity</spirit:name>
                        <spirit:description>msa h sync polarity (hsp)</spirit:description>
                        <spirit:bitOffset>15</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>sync_width</spirit:name>
                        <spirit:description>msa h sync width (hsw)</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>15</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>000000000100000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004484</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>vertical_0</spirit:name>
                     <spirit:addressOffset>0x10</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x08AE0050</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>total</spirit:name>
                        <spirit:description>msa v total</spirit:description>
                        <spirit:bitOffset>16</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000100010101110</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>start</spirit:name>
                        <spirit:description>msa v start</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000001010000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004488</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>vertical_1</spirit:name>
                     <spirit:addressOffset>0x14</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x08700005</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>height</spirit:name>
                        <spirit:description>msa v height</spirit:description>
                        <spirit:bitOffset>16</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000100001110000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>polarity</spirit:name>
                        <spirit:description>msa v sync polarity (vsp)</spirit:description>
                        <spirit:bitOffset>15</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>sync_width</spirit:name>
                        <spirit:description>msa v sync width (vsw)</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>15</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>000000000000101</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x8000448C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>misc</spirit:name>
                     <spirit:addressOffset>0x18</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000020</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>y_only</spirit:name>
                        <spirit:description>msa misc_1 bit 7 field for Y-only video</spirit:description>
                        <spirit:bitOffset>11</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>stereo</spirit:name>
                        <spirit:description>msa misc_1 bits 2:1 field for Stereo video attribute
0 = No 3D video</spirit:description>
                        <spirit:bitOffset>9</spirit:bitOffset>
                        <spirit:bitWidth>2</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>int_total</spirit:name>
                        <spirit:description>msa misc_1 bit 0 field for interlaced video</spirit:description>
                        <spirit:bitOffset>8</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>color</spirit:name>
                        <spirit:description>msa misc_0 bits 7:1 for the Colorimetry field
See DP 1.2 page 78
0x00 = RGB 18bpp
0x10 = RGB 24bpp
0x20 = RGB 30bpp
0x30 = RGB 36bpp
0x40 = RGB 48bpp</spirit:description>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>7</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0010000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>clk_sync</spirit:name>
                        <spirit:description>msa misc_0 bit 0 for synchronous clock.
0 = Link and main video clock are asynchronous
1 = Link and main video clock are synchronous</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004490</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004478</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : debug_msa  --> 
            <spirit:register>
                  <spirit:name>fsm_status</spirit:name>
                  <spirit:addressOffset>0x48</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>state_vid_status</spirit:name>
                     <spirit:description>state_vid_status
3'b000: e_wait_sr
3'b001: e_wait_vb
3'b010: e_wait_be
3'b011: e_valid
3'b100: e_dummy</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>3</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>state_ptp</spirit:name>
                     <spirit:description>state_ptp
2'b00: e_ptp_idle
2'b01: e_ptp_header
2'b10: e_ptp_data
2'b11: e_ptp_footer</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>2</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004494</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
  <!-- reg group
                    :vbd  --> 
          <spirit:registerFile>
                  <spirit:name>vbd</spirit:name>
                  <spirit:addressOffset>0x4C</spirit:addressOffset>
                  <spirit:range>0x8</spirit:range>            
                  <spirit:register>
                     <spirit:name>vbid</spirit:name>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>vbid</spirit:name>
                        <spirit:description>vbid value</spirit:description>
                        <spirit:bitOffset>16</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>maud</spirit:name>
                        <spirit:description>maud value</spirit:description>
                        <spirit:bitOffset>8</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>mvid</spirit:name>
                        <spirit:description>Lower 8 bits of mvid[31:0]</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004498</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>status</spirit:name>
                     <spirit:description>Stream_extractor module status register</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>vbd_majority_fail</spirit:name>
                        <spirit:description>VBID majority rule status. A "1" indicates that the majority rule failed</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x8000449C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004498</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : vbd  --> 
            <spirit:register>
                  <spirit:name>vid_fifo_config</spirit:name>
                  <spirit:addressOffset>0x54</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>depth</spirit:name>
                     <spirit:description>FIFO depth. This value is used for the build</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800044A0</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
  <!-- reg group
                    :sdp  --> 
          <spirit:registerFile>
                  <spirit:name>sdp</spirit:name>
                  <spirit:addressOffset>0x58</spirit:addressOffset>
                  <spirit:range>0x14</spirit:range>            
                  <spirit:register>
                     <spirit:name>fifo_status</spirit:name>
                     <spirit:description>SDP FIFO status register</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>overflow</spirit:name>
                        <spirit:description>FIFO overflow status. A "1" indicates overflow in FIFO.</spirit:description>
                        <spirit:bitOffset>3</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>underflow</spirit:name>
                        <spirit:description>FIFO underflow status. A "1" indicates underflow in FIFO.</spirit:description>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>full</spirit:name>
                        <spirit:description>FIFO full status. A "1" indicates FIFO is full</spirit:description>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>empty</spirit:name>
                        <spirit:description>FIFO empty status. A "1" indicates FIFO is empty</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x800044A4</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>tag_fifo_status</spirit:name>
                     <spirit:description>SDP tag FIFO status register</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>overflow</spirit:name>
                        <spirit:description>FIFO overflow status. A "1" indicates overflow in FIFO.</spirit:description>
                        <spirit:bitOffset>3</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>underflow</spirit:name>
                        <spirit:description>FIFO underflow status. A "1" indicates underflow in FIFO.</spirit:description>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>full</spirit:name>
                        <spirit:description>FIFO full status. A "1" indicates FIFO is full</spirit:description>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>empty</spirit:name>
                        <spirit:description>FIFO empty status. A "1" indicates FIFO is empty</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x800044A8</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>fifo_config</spirit:name>
                     <spirit:description>SDP fifo depths</spirit:description>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>depth</spirit:name>
                        <spirit:description>FIFO depth. This value is used for the build</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>9</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x800044AC</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>tag_fifo_config</spirit:name>
                     <spirit:description>SDP fifo depths</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>depth</spirit:name>
                        <spirit:description>FIFO depth. This value is used for the build</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>7</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x800044B0</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>debug</spirit:name>
                     <spirit:description>SDP The SS and SE symbols' byte number</spirit:description>
                     <spirit:addressOffset>0x10</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>ss_se_same_cycle_byte_num</spirit:name>
                        <spirit:description>FIFO depth. This value is used for the build</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x800044B4</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800044A4</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : sdp  --> 
            <spirit:register>
                  <spirit:name>pixgen</spirit:name>
                  <spirit:description>Pixel Generator</spirit:description>
                  <spirit:addressOffset>0x6C</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x000000FF</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>en</spirit:name>
                     <spirit:description>Pixel generator enable</spirit:description>
                     <spirit:bitOffset>31</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>blue</spirit:name>
                     <spirit:description>Pixel generator blue component</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>green</spirit:name>
                     <spirit:description>Pixel generator green component</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>red</spirit:name>
                     <spirit:description>Pixel generator red component</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>11111111</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800044B8</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>debug</spirit:name>
                  <spirit:description>Debug</spirit:description>
                  <spirit:addressOffset>0x70</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>idle_pattern_cnt</spirit:name>
                     <spirit:description>Idle pattern count</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>idle_pattern_cnt_rst</spirit:name>
                     <spirit:description>Idle pattern count reset</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800044BC</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x8000444C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : stream_extractor  --> 

  <!-- reg group
                    :encoder_vfr  --> 
          <spirit:registerFile>
               <spirit:name>encoder_vfr</spirit:name>
               <spirit:addressOffset>0xC0</spirit:addressOffset>
               <spirit:range>0xC</spirit:range>            
               <spirit:register>
                  <spirit:name>handshake</spirit:name>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>handshake</spirit:name>
                     <spirit:description>Number of images with a fault on handshake (vid_enbl='1' while vid_ready='0')</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800044C0</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pixel</spirit:name>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>last_early</spirit:name>
                     <spirit:description>Number of images with pixel_last flag assert too early (line is too small)</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>last_late</spirit:name>
                     <spirit:description>Number of images with pixel_last flag assert too late (line is too long)</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>first</spirit:name>
                     <spirit:description>Number of images with pixel_first flag at the wrong position</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800044C4</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>line</spirit:name>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>last_early</spirit:name>
                     <spirit:description>Number of images with line_last flag assert too early (line is too small)</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>last_late</spirit:name>
                     <spirit:description>Number of images with line_last flag assert too late (line is too long)</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>first</spirit:name>
                     <spirit:description>Number of images with line_first flag at the wrong position</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800044C8</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x800044C0</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : encoder_vfr  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
               <spirit:name>stats0</spirit:name>
               <spirit:description>All the Statistic Registers and their configuration.</spirit:description>
               <spirit:addressOffset>0xCC</spirit:addressOffset>
               <spirit:range>0x60</spirit:range>            
               <spirit:register>
                  <spirit:name>rd2clr_config</spirit:name>
                  <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>msa_majority_fail</spirit:name>
                     <spirit:bitOffset>22</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>vbd_majority_fail</spirit:name>
                     <spirit:bitOffset>21</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>vid_c2_sr_full</spirit:name>
                     <spirit:bitOffset>20</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>vid_c2_fifo_level_watermark</spirit:name>
                     <spirit:bitOffset>19</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>vid_c2_fifo_level</spirit:name>
                     <spirit:bitOffset>18</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>vid_c2_fifo_underflow</spirit:name>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>vid_c2_fifo_overflow</spirit:name>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>vid_c2_fifo_empty</spirit:name>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>vid_c2_fifo_full</spirit:name>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>vid_c1_sr_full</spirit:name>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>vid_c1_fifo_level_watermark</spirit:name>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>vid_c1_fifo_level</spirit:name>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>vid_c1_fifo_underflow</spirit:name>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>vid_c1_fifo_overflow</spirit:name>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>vid_c1_fifo_empty</spirit:name>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>vid_c1_fifo_full</spirit:name>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>vid_c0_sr_full</spirit:name>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>vid_c0_fifo_level_watermark</spirit:name>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>vid_c0_fifo_level</spirit:name>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>vid_c0_fifo_underflow</spirit:name>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>vid_c0_fifo_overflow</spirit:name>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>vid_c0_fifo_empty</spirit:name>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>vid_c0_fifo_full</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x800044CC</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>vid_c0_fifo_full</spirit:name>
                  <spirit:description>Pixel C0 FIFO full count</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>vid_c0_fifo_full</spirit:name>
                     <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x800044D0</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>vid_c0_fifo_empty</spirit:name>
                  <spirit:description>Pixel C0 FIFO empty count</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>vid_c0_fifo_empty</spirit:name>
                     <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x800044D4</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>vid_c0_fifo_overflow</spirit:name>
                  <spirit:description>Pixel C0 FIFO overflow count</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>vid_c0_fifo_overflow</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x800044D8</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>vid_c0_fifo_underflow</spirit:name>
                  <spirit:description>Pixel C0 FIFO underflow count</spirit:description>
                  <spirit:addressOffset>0x10</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>vid_c0_fifo_underflow</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x800044DC</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>vid_c0_fifo_level</spirit:name>
                  <spirit:description>Pixel C0 FIFO level</spirit:description>
                  <spirit:addressOffset>0x14</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>vid_c0_fifo_level</spirit:name>
                     <spirit:description>_icron_no_counter_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x800044E0</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>vid_c0_fifo_level_watermark</spirit:name>
                  <spirit:description>Pixel C0 FIFO level Watermark</spirit:description>
                  <spirit:addressOffset>0x18</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>vid_c0_fifo_level_watermark</spirit:name>
                     <spirit:description>_icron_no_counter_;_icron_water_marker_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x800044E4</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>vid_c0_sr_full</spirit:name>
                  <spirit:description>Pixel C0 SR full</spirit:description>
                  <spirit:addressOffset>0x1C</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>vid_c0_sr_full</spirit:name>
                     <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x800044E8</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>vid_c1_fifo_full</spirit:name>
                  <spirit:description>Pixel C1 FIFO full count</spirit:description>
                  <spirit:addressOffset>0x20</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>vid_c1_fifo_full</spirit:name>
                     <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x800044EC</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>vid_c1_fifo_empty</spirit:name>
                  <spirit:description>Pixel C1 FIFO empty count</spirit:description>
                  <spirit:addressOffset>0x24</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>vid_c1_fifo_empty</spirit:name>
                     <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x800044F0</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>vid_c1_fifo_overflow</spirit:name>
                  <spirit:description>Pixel C1 FIFO overflow count</spirit:description>
                  <spirit:addressOffset>0x28</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>vid_c1_fifo_overflow</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x800044F4</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>vid_c1_fifo_underflow</spirit:name>
                  <spirit:description>Pixel C1 FIFO underflow count</spirit:description>
                  <spirit:addressOffset>0x2C</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>vid_c1_fifo_underflow</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x800044F8</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>vid_c1_fifo_level</spirit:name>
                  <spirit:description>Pixel C1 FIFO level</spirit:description>
                  <spirit:addressOffset>0x30</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>vid_c1_fifo_level</spirit:name>
                     <spirit:description>_icron_no_counter_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x800044FC</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>vid_c1_fifo_level_watermark</spirit:name>
                  <spirit:description>Pixel C1 FIFO level Watermark</spirit:description>
                  <spirit:addressOffset>0x34</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>vid_c1_fifo_level_watermark</spirit:name>
                     <spirit:description>_icron_no_counter_;_icron_water_marker_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004500</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>vid_c1_sr_full</spirit:name>
                  <spirit:description>Pixel C1 SR full</spirit:description>
                  <spirit:addressOffset>0x38</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>vid_c1_sr_full</spirit:name>
                     <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004504</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>vid_c2_fifo_full</spirit:name>
                  <spirit:description>Pixel C2 FIFO full count</spirit:description>
                  <spirit:addressOffset>0x3C</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>vid_c2_fifo_full</spirit:name>
                     <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004508</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>vid_c2_fifo_empty</spirit:name>
                  <spirit:description>Pixel C2 FIFO empty count</spirit:description>
                  <spirit:addressOffset>0x40</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>vid_c2_fifo_empty</spirit:name>
                     <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x8000450C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>vid_c2_fifo_overflow</spirit:name>
                  <spirit:description>Pixel C2 FIFO overflow count</spirit:description>
                  <spirit:addressOffset>0x44</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>vid_c2_fifo_overflow</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004510</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>vid_c2_fifo_underflow</spirit:name>
                  <spirit:description>Pixel C2 FIFO underflow count</spirit:description>
                  <spirit:addressOffset>0x48</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>vid_c2_fifo_underflow</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004514</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>vid_c2_fifo_level</spirit:name>
                  <spirit:description>Pixel C2 FIFO level</spirit:description>
                  <spirit:addressOffset>0x4C</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>vid_c2_fifo_level</spirit:name>
                     <spirit:description>_icron_no_counter_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004518</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>vid_c2_fifo_level_watermark</spirit:name>
                  <spirit:description>Pixel C2 FIFO level Watermark</spirit:description>
                  <spirit:addressOffset>0x50</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>vid_c2_fifo_level_watermark</spirit:name>
                     <spirit:description>_icron_no_counter_;_icron_water_marker_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x8000451C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>vid_c2_sr_full</spirit:name>
                  <spirit:description>Pixel C2 SR full</spirit:description>
                  <spirit:addressOffset>0x54</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>vid_c2_sr_full</spirit:name>
                     <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004520</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>vbd_majority_fail</spirit:name>
                  <spirit:description>VBD majority fail count</spirit:description>
                  <spirit:addressOffset>0x58</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>vbd_majority_fail</spirit:name>
                     <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004524</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>msa_majority_fail</spirit:name>
                  <spirit:description>MSA majority fail count</spirit:description>
                  <spirit:addressOffset>0x5C</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>msa_majority_fail</spirit:name>
                     <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004528</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x800044CC</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 

  <!-- reg group
                    :stats1  --> 
          <spirit:registerFile>
               <spirit:name>stats1</spirit:name>
               <spirit:description>All the Statistic Registers and their configuration.</spirit:description>
               <spirit:addressOffset>0x12C</spirit:addressOffset>
               <spirit:range>0x40</spirit:range>            
               <spirit:register>
                  <spirit:name>rd2clr_config</spirit:name>
                  <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>sdp_tag_fifo_level_watermark</spirit:name>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sdp_tag_fifo_level</spirit:name>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sdp_tag_fifo_underflow</spirit:name>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sdp_tag_fifo_overflow</spirit:name>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sdp_tag_fifo_empty</spirit:name>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sdp_tag_fifo_full</spirit:name>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sdp_fifo_level_watermark</spirit:name>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sdp_fifo_level</spirit:name>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sdp_fifo_underflow</spirit:name>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sdp_fifo_overflow</spirit:name>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sdp_fifo_empty</spirit:name>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sdp_fifo_full</spirit:name>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sdp_ss_se_same_cycle</spirit:name>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sdp_pkt_sent_cnt_watermark</spirit:name>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sdp_pkt_sent_cnt</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x8000452C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>sdp_pkt_sent_cnt</spirit:name>
                  <spirit:description>SDP Number of PTP packets sent</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>sdp_pkt_sent_cnt</spirit:name>
                     <spirit:description>_icron_no_counter_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004530</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>sdp_pkt_sent_cnt_watermark</spirit:name>
                  <spirit:description>SDP Number of packets sent watermark</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>sdp_pkt_sent_cnt_watermark</spirit:name>
                     <spirit:description>_icron_no_counter_;_icron_water_marker_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004534</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>sdp_ss_se_same_cycle</spirit:name>
                  <spirit:description>SDP number of clock cycles with ss and se</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>sdp_ss_se_same_cycle</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004538</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>sdp_fifo_full</spirit:name>
                  <spirit:description>SDP FIFO full count</spirit:description>
                  <spirit:addressOffset>0x10</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>sdp_fifo_full</spirit:name>
                     <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x8000453C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>sdp_fifo_empty</spirit:name>
                  <spirit:description>SDP FIFO empty count</spirit:description>
                  <spirit:addressOffset>0x14</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>sdp_fifo_empty</spirit:name>
                     <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004540</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>sdp_fifo_overflow</spirit:name>
                  <spirit:description>SDP FIFO overflow count</spirit:description>
                  <spirit:addressOffset>0x18</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>sdp_fifo_overflow</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004544</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>sdp_fifo_underflow</spirit:name>
                  <spirit:description>SDP FIFO underflow count</spirit:description>
                  <spirit:addressOffset>0x1C</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>sdp_fifo_underflow</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004548</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>sdp_fifo_level</spirit:name>
                  <spirit:description>SDP FIFO level</spirit:description>
                  <spirit:addressOffset>0x20</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>sdp_fifo_level</spirit:name>
                     <spirit:description>_icron_no_counter_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x8000454C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>sdp_fifo_level_watermark</spirit:name>
                  <spirit:description>SDP FIFO level Watermark</spirit:description>
                  <spirit:addressOffset>0x24</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>sdp_fifo_level_watermark</spirit:name>
                     <spirit:description>_icron_no_counter_;_icron_water_marker_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004550</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>sdp_tag_fifo_full</spirit:name>
                  <spirit:description>SDP TAG FIFO full count</spirit:description>
                  <spirit:addressOffset>0x28</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>sdp_tag_fifo_full</spirit:name>
                     <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004554</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>sdp_tag_fifo_empty</spirit:name>
                  <spirit:description>SDP TAG FIFO empty count</spirit:description>
                  <spirit:addressOffset>0x2C</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>sdp_tag_fifo_empty</spirit:name>
                     <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004558</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>sdp_tag_fifo_overflow</spirit:name>
                  <spirit:description>SDP TAG FIFO overflow count</spirit:description>
                  <spirit:addressOffset>0x30</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>sdp_tag_fifo_overflow</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x8000455C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>sdp_tag_fifo_underflow</spirit:name>
                  <spirit:description>SDP TAG FIFO underflow count</spirit:description>
                  <spirit:addressOffset>0x34</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>sdp_tag_fifo_underflow</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004560</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>sdp_tag_fifo_level</spirit:name>
                  <spirit:description>SDP TAG FIFO level</spirit:description>
                  <spirit:addressOffset>0x38</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>sdp_tag_fifo_level</spirit:name>
                     <spirit:description>_icron_no_counter_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004564</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>sdp_tag_fifo_level_watermark</spirit:name>
                  <spirit:description>SDP TAG FIFO level Watermark</spirit:description>
                  <spirit:addressOffset>0x3C</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>sdp_tag_fifo_level_watermark</spirit:name>
                     <spirit:description>_icron_no_counter_;_icron_water_marker_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004568</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x8000452C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : stats1  --> 

  <!-- reg group
                    :irq  --> 
          <spirit:registerFile>
               <spirit:name>irq</spirit:name>
               <spirit:description>source Interrupt register group</spirit:description>
               <spirit:addressOffset>0x16C</spirit:addressOffset>
               <spirit:range>0x10</spirit:range>            
               <spirit:register>
                  <spirit:name>enable</spirit:name>
                  <spirit:description>Interrupt Enable register - Write 1 to enable, 0 to mask an interrupt
</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>audiomute</spirit:name>
                     <spirit:description>Set high to enable AudioMute_Flag</spirit:description>
                     <spirit:bitOffset>31</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>novideostream</spirit:name>
                     <spirit:description>Set high to enable NoVideoStream_Flag</spirit:description>
                     <spirit:bitOffset>30</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_gt_rxbyterealign</spirit:name>
                     <spirit:description>Set high to enable dp_gt_rxbyterealign</spirit:description>
                     <spirit:bitOffset>29</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>first_idle_pattern</spirit:name>
                     <spirit:description>Set high to enable first_idle_pattern</spirit:description>
                     <spirit:bitOffset>28</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lanes_with_8b10b_err_post_cr</spirit:name>
                     <spirit:description>Set high to enable lanes_with_8b10b_err_post_cr</spirit:description>
                     <spirit:bitOffset>27</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lanes_not_aligned</spirit:name>
                     <spirit:description>Set high to enable lanes_not_aligned</spirit:description>
                     <spirit:bitOffset>25</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>bond_align_done</spirit:name>
                     <spirit:description>Set high to enable bond_align_done</spirit:description>
                     <spirit:bitOffset>24</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>stream_extractor_vid_fifo_underflow3</spirit:name>
                     <spirit:description>Set high to enable stream_extractor_vid_fifo_underflow</spirit:description>
                     <spirit:bitOffset>23</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>stream_extractor_vid_fifo_underflow2</spirit:name>
                     <spirit:description>Set high to enable stream_extractor_vid_fifo_underflow</spirit:description>
                     <spirit:bitOffset>22</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>stream_extractor_vid_fifo_underflow1</spirit:name>
                     <spirit:description>Set high to enable stream_extractor_vid_fifo_underflow</spirit:description>
                     <spirit:bitOffset>21</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>stream_extractor_vid_fifo_underflow0</spirit:name>
                     <spirit:description>Set high to enable stream_extractor_vid_fifo_underflow</spirit:description>
                     <spirit:bitOffset>20</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>stream_extractor_vid_fifo_overflow3</spirit:name>
                     <spirit:description>Set high to enable stream_extractor_vid_fifo_overflow</spirit:description>
                     <spirit:bitOffset>19</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>stream_extractor_vid_fifo_overflow2</spirit:name>
                     <spirit:description>Set high to enable stream_extractor_vid_fifo_overflow</spirit:description>
                     <spirit:bitOffset>18</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>stream_extractor_vid_fifo_overflow1</spirit:name>
                     <spirit:description>Set high to enable stream_extractor_vid_fifo_overflow</spirit:description>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>stream_extractor_vid_fifo_overflow0</spirit:name>
                     <spirit:description>Set high to enable stream_extractor_vid_fifo_overflow</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>aligner_fifo_underflow3</spirit:name>
                     <spirit:description>Set high to enable aligner_fifo_underflow</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>aligner_fifo_underflow2</spirit:name>
                     <spirit:description>Set high to enable aligner_fifo_underflow</spirit:description>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>aligner_fifo_underflow1</spirit:name>
                     <spirit:description>Set high to enable aligner_fifo_underflow</spirit:description>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>aligner_fifo_underflow0</spirit:name>
                     <spirit:description>Set high to enable aligner_fifo_underflow</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>aligner_fifo_overflow3</spirit:name>
                     <spirit:description>Set high to enable aligner_fifo_overflow</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>aligner_fifo_overflow2</spirit:name>
                     <spirit:description>Set high to enable aligner_fifo_overflow</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>aligner_fifo_overflow1</spirit:name>
                     <spirit:description>Set high to enable aligner_fifo_overflow</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>aligner_fifo_overflow0</spirit:name>
                     <spirit:description>Set high to enable aligner_fifo_overflow</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sdp_tag_fifo_underflow</spirit:name>
                     <spirit:description>Set high to enable sdp_tag_fifo_underflow</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sdp_tag_fifo_overflow</spirit:name>
                     <spirit:description>Set high to enable sdp_tag_fifo_overflow</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sdp_fifo_underflow</spirit:name>
                     <spirit:description>Set high to enable sdp_fifo_underflow</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sdp_fifo_overflow</spirit:name>
                     <spirit:description>Set high to enable sdp_fifo_overflow</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>msa_majority_fail</spirit:name>
                     <spirit:description>Set high to enable msa_majority_fail</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>vbd_majority_fail</spirit:name>
                     <spirit:description>Set high to enable vbd_majority_fail</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tu_size_rdy</spirit:name>
                     <spirit:description>Set high to enable tu_size_rdy interrupt</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000456C</address>
                        <intr.enable>irq0_dp_sink_main</intr.enable>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending</spirit:name>
                  <spirit:description>Interrupt Pending register - This indicates which enabled interrupts have triggered, Write 1 to clear
</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>audiomute</spirit:name>
                     <spirit:description>Registered AudioMute_Flag</spirit:description>
                     <spirit:bitOffset>31</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>novideostream</spirit:name>
                     <spirit:description>Registered NoVideoStream_Flag</spirit:description>
                     <spirit:bitOffset>30</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_gt_rxbyterealign</spirit:name>
                     <spirit:description>Registered dp_gtp_rxbyterealign</spirit:description>
                     <spirit:bitOffset>29</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>first_idle_pattern</spirit:name>
                     <spirit:description>Registered first idle pattern</spirit:description>
                     <spirit:bitOffset>28</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lanes_with_8b10b_err_post_cr</spirit:name>
                     <spirit:description>Registered lanes_with_8b10b_err_post_cr</spirit:description>
                     <spirit:bitOffset>27</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lanes_not_aligned</spirit:name>
                     <spirit:description>Registered lanes_not_aligned</spirit:description>
                     <spirit:bitOffset>25</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>bond_align_done</spirit:name>
                     <spirit:description>Registered bond_align_done</spirit:description>
                     <spirit:bitOffset>24</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>stream_extractor_vid_fifo_underflow3</spirit:name>
                     <spirit:description>Registered stream_extractor_vid_fifo_underflow</spirit:description>
                     <spirit:bitOffset>23</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>stream_extractor_vid_fifo_underflow2</spirit:name>
                     <spirit:description>Registered stream_extractor_vid_fifo_underflow</spirit:description>
                     <spirit:bitOffset>22</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>stream_extractor_vid_fifo_underflow1</spirit:name>
                     <spirit:description>Registered stream_extractor_vid_fifo_underflow</spirit:description>
                     <spirit:bitOffset>21</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>stream_extractor_vid_fifo_underflow0</spirit:name>
                     <spirit:description>Registered stream_extractor_vid_fifo_underflow</spirit:description>
                     <spirit:bitOffset>20</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>stream_extractor_vid_fifo_overflow3</spirit:name>
                     <spirit:description>Registered stream_extractor_vid_fifo_overflow</spirit:description>
                     <spirit:bitOffset>19</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>stream_extractor_vid_fifo_overflow2</spirit:name>
                     <spirit:description>Registered stream_extractor_vid_fifo_overflow</spirit:description>
                     <spirit:bitOffset>18</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>stream_extractor_vid_fifo_overflow1</spirit:name>
                     <spirit:description>Registered stream_extractor_vid_fifo_overflow</spirit:description>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>stream_extractor_vid_fifo_overflow0</spirit:name>
                     <spirit:description>Registered stream_extractor_vid_fifo_overflow</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>aligner_fifo_underflow3</spirit:name>
                     <spirit:description>Registered aligner_fifo_underflow</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>aligner_fifo_underflow2</spirit:name>
                     <spirit:description>Registered aligner_fifo_underflow</spirit:description>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>aligner_fifo_underflow1</spirit:name>
                     <spirit:description>Registered aligner_fifo_underflow</spirit:description>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>aligner_fifo_underflow0</spirit:name>
                     <spirit:description>Registered aligner_fifo_underflow</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>aligner_fifo_overflow3</spirit:name>
                     <spirit:description>Registered aligner_fifo_overflow</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>aligner_fifo_overflow2</spirit:name>
                     <spirit:description>Registered aligner_fifo_overflow</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>aligner_fifo_overflow1</spirit:name>
                     <spirit:description>Registered aligner_fifo_overflow</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>aligner_fifo_overflow0</spirit:name>
                     <spirit:description>Registered aligner_fifo_overflow</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sdp_tag_fifo_underflow</spirit:name>
                     <spirit:description>Registered sdp_tag_fifo_underflow</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sdp_tag_fifo_overflow</spirit:name>
                     <spirit:description>Registered sdp_tag_fifo_overflow</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sdp_fifo_underflow</spirit:name>
                     <spirit:description>Registered sdp_fifo_underflow</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sdp_fifo_overflow</spirit:name>
                     <spirit:description>Registered sdp_fifo_overflow</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>msa_majority_fail</spirit:name>
                     <spirit:description>Registered msa_majority_fail</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>vbd_majority_fail</spirit:name>
                     <spirit:description>Registered vbd_majority_fail</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tu_size_rdy</spirit:name>
                     <spirit:description>Registered tu_size_rdy 
1: TU size value is ready to be read
0: TU is not ready or not applicable</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004570</address>
                        <intr.status>irq0_dp_sink_main</intr.status>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending_irq</spirit:name>
                  <spirit:description>Interrupt Pending register - This indicates which enabled interrupts have triggered, Write 1 to clear
</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>audiomute</spirit:name>
                     <spirit:description>Registered AudioMute_Flag</spirit:description>
                     <spirit:bitOffset>31</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>novideostream</spirit:name>
                     <spirit:description>Registered NoVideoStream_Flag</spirit:description>
                     <spirit:bitOffset>30</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_gt_rxbyterealign</spirit:name>
                     <spirit:description>Registered dp_gtp_rxbyterealign</spirit:description>
                     <spirit:bitOffset>29</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>first_idle_pattern</spirit:name>
                     <spirit:description>Registered first idle pattern</spirit:description>
                     <spirit:bitOffset>28</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lanes_with_8b10b_err_post_cr</spirit:name>
                     <spirit:description>Registered lanes_with_8b10b_err_post_cr</spirit:description>
                     <spirit:bitOffset>27</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lanes_not_aligned</spirit:name>
                     <spirit:description>Registered lanes_not_aligned</spirit:description>
                     <spirit:bitOffset>25</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>bond_align_done</spirit:name>
                     <spirit:description>Registered bond_align_done</spirit:description>
                     <spirit:bitOffset>24</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>stream_extractor_vid_fifo_underflow3</spirit:name>
                     <spirit:description>Registered stream_extractor_vid_fifo_underflow</spirit:description>
                     <spirit:bitOffset>23</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>stream_extractor_vid_fifo_underflow2</spirit:name>
                     <spirit:description>Registered stream_extractor_vid_fifo_underflow</spirit:description>
                     <spirit:bitOffset>22</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>stream_extractor_vid_fifo_underflow1</spirit:name>
                     <spirit:description>Registered stream_extractor_vid_fifo_underflow</spirit:description>
                     <spirit:bitOffset>21</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>stream_extractor_vid_fifo_underflow0</spirit:name>
                     <spirit:description>Registered stream_extractor_vid_fifo_underflow</spirit:description>
                     <spirit:bitOffset>20</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>stream_extractor_vid_fifo_overflow3</spirit:name>
                     <spirit:description>Registered stream_extractor_vid_fifo_overflow</spirit:description>
                     <spirit:bitOffset>19</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>stream_extractor_vid_fifo_overflow2</spirit:name>
                     <spirit:description>Registered stream_extractor_vid_fifo_overflow</spirit:description>
                     <spirit:bitOffset>18</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>stream_extractor_vid_fifo_overflow1</spirit:name>
                     <spirit:description>Registered stream_extractor_vid_fifo_overflow</spirit:description>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>stream_extractor_vid_fifo_overflow0</spirit:name>
                     <spirit:description>Registered stream_extractor_vid_fifo_overflow</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>aligner_fifo_underflow3</spirit:name>
                     <spirit:description>Registered aligner_fifo_underflow</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>aligner_fifo_underflow2</spirit:name>
                     <spirit:description>Registered aligner_fifo_underflow</spirit:description>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>aligner_fifo_underflow1</spirit:name>
                     <spirit:description>Registered aligner_fifo_underflow</spirit:description>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>aligner_fifo_underflow0</spirit:name>
                     <spirit:description>Registered aligner_fifo_underflow</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>aligner_fifo_overflow3</spirit:name>
                     <spirit:description>Registered aligner_fifo_overflow</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>aligner_fifo_overflow2</spirit:name>
                     <spirit:description>Registered aligner_fifo_overflow</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>aligner_fifo_overflow1</spirit:name>
                     <spirit:description>Registered aligner_fifo_overflow</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>aligner_fifo_overflow0</spirit:name>
                     <spirit:description>Registered aligner_fifo_overflow</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sdp_tag_fifo_underflow</spirit:name>
                     <spirit:description>Registered sdp_tag_fifo_underflow</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sdp_tag_fifo_overflow</spirit:name>
                     <spirit:description>Registered sdp_tag_fifo_overflow</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sdp_fifo_underflow</spirit:name>
                     <spirit:description>Registered sdp_fifo_underflow</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sdp_fifo_overflow</spirit:name>
                     <spirit:description>Registered sdp_fifo_overflow</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>msa_majority_fail</spirit:name>
                     <spirit:description>Registered msa_majority_fail</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>vbd_majority_fail</spirit:name>
                     <spirit:description>Registered vbd_majority_fail</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tu_size_rdy</spirit:name>
                     <spirit:description>Registered tu_size_rdy 
1: TU size value is ready to be read
0: TU is not ready or not applicable</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004574</address>
                        <intr.pending>irq0_dp_sink_main</intr.pending>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>raw</spirit:name>
                  <spirit:description>This register contains the registered state of interrupt signals</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>audiomute</spirit:name>
                     <spirit:description>Current status of AudioMute_Flag</spirit:description>
                     <spirit:bitOffset>31</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>novideostream</spirit:name>
                     <spirit:description>Current status of NoVideoStream_Flag</spirit:description>
                     <spirit:bitOffset>30</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_gt_rxbyterealign</spirit:name>
                     <spirit:description>Current status of dp_gtp_rxbyterealign</spirit:description>
                     <spirit:bitOffset>29</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>first_idle_pattern</spirit:name>
                     <spirit:description>Current status of first_idle_pattern</spirit:description>
                     <spirit:bitOffset>28</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lanes_with_8b10b_err_post_cr</spirit:name>
                     <spirit:description>Current status of lanes_with_8b10b_err_post_cr</spirit:description>
                     <spirit:bitOffset>27</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>lanes_not_aligned</spirit:name>
                     <spirit:description>Current status of lanes_not_aligned</spirit:description>
                     <spirit:bitOffset>25</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>bond_align_done</spirit:name>
                     <spirit:description>Current status of bond_align_done</spirit:description>
                     <spirit:bitOffset>24</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>stream_extractor_vid_fifo_underflow3</spirit:name>
                     <spirit:description>Current status of stream_extractor_vid_fifo_underflow</spirit:description>
                     <spirit:bitOffset>23</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>stream_extractor_vid_fifo_underflow2</spirit:name>
                     <spirit:description>Current status of stream_extractor_vid_fifo_underflow</spirit:description>
                     <spirit:bitOffset>22</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>stream_extractor_vid_fifo_underflow1</spirit:name>
                     <spirit:description>Current status of stream_extractor_vid_fifo_underflow</spirit:description>
                     <spirit:bitOffset>21</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>stream_extractor_vid_fifo_underflow0</spirit:name>
                     <spirit:description>Current status of stream_extractor_vid_fifo_underflow</spirit:description>
                     <spirit:bitOffset>20</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>stream_extractor_vid_fifo_overflow3</spirit:name>
                     <spirit:description>Current status of stream_extractor_vid_fifo_overflow</spirit:description>
                     <spirit:bitOffset>19</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>stream_extractor_vid_fifo_overflow2</spirit:name>
                     <spirit:description>Current status of stream_extractor_vid_fifo_overflow</spirit:description>
                     <spirit:bitOffset>18</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>stream_extractor_vid_fifo_overflow1</spirit:name>
                     <spirit:description>Current status of stream_extractor_vid_fifo_overflow</spirit:description>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>stream_extractor_vid_fifo_overflow0</spirit:name>
                     <spirit:description>Current status of stream_extractor_vid_fifo_overflow</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>aligner_fifo_underflow3</spirit:name>
                     <spirit:description>Current status of aligner_fifo_underflow</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>aligner_fifo_underflow2</spirit:name>
                     <spirit:description>Current status of aligner_fifo_underflow</spirit:description>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>aligner_fifo_underflow1</spirit:name>
                     <spirit:description>Current status of aligner_fifo_underflow</spirit:description>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>aligner_fifo_underflow0</spirit:name>
                     <spirit:description>Current status of aligner_fifo_underflow</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>aligner_fifo_overflow3</spirit:name>
                     <spirit:description>Current status of aligner_fifo_overflow</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>aligner_fifo_overflow2</spirit:name>
                     <spirit:description>Current status of aligner_fifo_overflow</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>aligner_fifo_overflow1</spirit:name>
                     <spirit:description>Current status of aligner_fifo_overflow</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>aligner_fifo_overflow0</spirit:name>
                     <spirit:description>Current status of aligner_fifo_overflow</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sdp_tag_fifo_underflow</spirit:name>
                     <spirit:description>Current status of sdp_tag_fifo_underflow</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sdp_tag_fifo_overflow</spirit:name>
                     <spirit:description>Current status of sdp_tag_fifo_overflow</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sdp_fifo_underflow</spirit:name>
                     <spirit:description>Current status of sdp_fifo_underflow</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sdp_fifo_overflow</spirit:name>
                     <spirit:description>Current status of sdp_fifo_overflow</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>msa_majority_fail</spirit:name>
                     <spirit:description>Current status of msa_majority_fail</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>vbd_majority_fail</spirit:name>
                     <spirit:description>Current status of vbd_majority_fail</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>tu_size_rdy</spirit:name>
                     <spirit:description>Current status of tu_size_rdy</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004578</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x8000456C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : irq  --> 
         <spirit:vendorExtensions>
               <ids_properties>
                  <module_name>dp_sink_regs</module_name>
                  <uvm.package>dp_sink_regs_pkg</uvm.package>
                  <reset_type>async</reset_type>
                  <cheader.mask_endianess>little</cheader.mask_endianess>
                  <explicit_name>true</explicit_name>
                  <header.struct_guard>__ASSEMBLER__</header.struct_guard>
                  <vertical_reuse>true</vertical_reuse>
                  <address>0x80004400</address>
               </ids_properties>
            </spirit:vendorExtensions>
         </spirit:addressBlock>     
         <spirit:addressBlock>     
            <spirit:name>dp_sink_tico</spirit:name>  <!-- //
                        block : dp_sink_tico  --> 
            <spirit:baseAddress>0x80004600</spirit:baseAddress>               
            <spirit:range>0x100</spirit:range>               
            <spirit:width>32</spirit:width>            
            <spirit:register>
               <spirit:name>tico_e_width</spirit:name>
               <spirit:addressOffset>0x14</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>tico_e_width</spirit:name>
                  <spirit:description>Image width, in pixels.
Must be a multiple of 2.
Up to 2048 for HD core flavor, 4096 for 4K core flavor, 8192 for 8K core flavor, and 10240 for 10K core flavor.</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>16</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0000000000000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004614</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>tico_e_height</spirit:name>
               <spirit:addressOffset>0x1C</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>tico_e_height</spirit:name>
                  <spirit:description>Image height, in pixels.
Must be a multiple of 2, and greater than or equal to 2 in profile 1, 8 in profile 2.</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>16</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0000000000000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x8000461C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>tico_e_comp</spirit:name>
               <spirit:addressOffset>0x24</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>tico_e_comp</spirit:name>
                  <spirit:description>Number of color components. Fixed to 3.</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>2</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004624</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>tico_e_mode</spirit:name>
               <spirit:addressOffset>0x2C</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000001</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>tico_e_mode</spirit:name>
                  <spirit:description>Configures the color format and sub-sampling

- 4'b0000: RGB
- 4'b0001 YCbCr422
- 4'b1000 YCbCr444 
</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>4</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0001</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x8000462C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>tico_e_hlvls</spirit:name>
               <spirit:addressOffset>0x34</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>tico_e_hlvls</spirit:name>
                  <spirit:description>Number of horizontal decompositions in the horizontal wavelet transform. Fixed to 5.</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>3</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004634</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>tico_e_vld</spirit:name>
               <spirit:addressOffset>0x38</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>tico_e_vld</spirit:name>
                  <spirit:description>It validates the given configuration.
Set to '1' to start the core, after setting mode and images parameters.
Note: to start the core, the user_rst signal must also be inactive.</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>write-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004638</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>tico_e_nbr</spirit:name>
               <spirit:addressOffset>0x3C</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>tico_e_nbr</spirit:name>
                  <spirit:description>Number of images to play when the core is in command
mode.</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>16</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0000000000000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x8000463C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>tico_e_bgt</spirit:name>
               <spirit:addressOffset>0x44</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>tico_e_bgt</spirit:name>
                  <spirit:description>Budget in bytes for a single picture.
The budget is allocated to the picture header and the compressed data.
Note: To compute this value according to a bit per pixel rate:
budget = bpp x width x height / 8</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>32</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000000000000000000000000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004644</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>tico_e_vid_depth</spirit:name>
               <spirit:addressOffset>0x48</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>tico_e_vid_depth</spirit:name>
                  <spirit:description>Bit depth of the video content, mapped on the MSBs of the port interface.
The valid bit depths are 8, 10 and 12 bits per component

4'b1000: 8 bits
4'b1010: 10 bits
4'b1100: 12 bits</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>4</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004648</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>tico_e_play_mode</spirit:name>
               <spirit:addressOffset>0x4C</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>tico_e_play_mode</spirit:name>
                  <spirit:description>It allows to choose between two running modes:
- set to '1' to run in play mode, in which the core processes frames continuously.
- set to '0' to run in command mode, in which the core processes n frames, n defined by TICO_E_NBR.</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>write-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x8000464C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>tico_e_lvl_weights</spirit:name>
               <spirit:addressOffset>0x50</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>tico_e_lvl_weights</spirit:name>
                  <spirit:description>This register is used to program the image quality optimization (visual or PSNR), see Rate allocation configuration and optimization (page 24) section for more details.</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>32</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000000000000000000000000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004650</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>         
            <spirit:vendorExtensions>
               <ids_properties>
                  <module_name>tico_encoder_regs</module_name>
                  <uvm.package>tico_encoder_regs_pkg</uvm.package>
                  <reset_type>async</reset_type>
                  <cheader.mask_endianess>little</cheader.mask_endianess>
                  <explicit_name>true</explicit_name>
                  <header.struct_guard>__ASSEMBLER__</header.struct_guard>
                  <vertical_reuse>true</vertical_reuse>
                  <address>0x80004600</address>
               </ids_properties>
            </spirit:vendorExtensions>
         </spirit:addressBlock>     
         <spirit:addressBlock>     
            <spirit:name>dp_sink_aux_hpd</spirit:name>
            <spirit:description>DP aux hpd
</spirit:description>  <!-- //
                        block : dp_sink_aux_hpd  --> 
            <spirit:baseAddress>0x80004700</spirit:baseAddress>               
            <spirit:range>0x100</spirit:range>               
            <spirit:width>32</spirit:width>            
            <spirit:register>
               <spirit:name>version</spirit:name>
               <spirit:description>Version</spirit:description>
               <spirit:addressOffset>0x0</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00040400</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>major</spirit:name>
                  <spirit:description>Major version</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000100</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>minor</spirit:name>
                  <spirit:description>Minor version</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000100</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>patch</spirit:name>
                  <spirit:description>Patch version</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004700</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>aux_status</spirit:name>
               <spirit:description>Error bits for source/sink and misc status bits</spirit:description>
               <spirit:addressOffset>0x4</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0xA0000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>aux_sense_p_in_debounce</spirit:name>
                  <spirit:description>Aux + line status after de-bouncing 
1: DP source device is not connected
0: DP source device is connected</spirit:description>
                  <spirit:bitOffset>31</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>1</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>aux_sense_n_in_debounce</spirit:name>
                  <spirit:description>Aux - line status after de-bouncing

1: DP source device provides power on DP_PWR pin
0: DP source device does not provide power for sink</spirit:description>
                  <spirit:bitOffset>30</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>aux_sense_p_in</spirit:name>
                  <spirit:description>Aux + line status 
1: DP source device is not connected
0: DP source device is connected</spirit:description>
                  <spirit:bitOffset>29</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>1</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>aux_sense_n_in</spirit:name>
                  <spirit:description>Aux - line status 
1: DP source device provides power on DP_PWR pin
0: DP source device does not provide power for sink</spirit:description>
                  <spirit:bitOffset>28</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>sent_defer_cnt</spirit:name>
                  <spirit:description>Number of sent defers</spirit:description>
                  <spirit:bitOffset>24</spirit:bitOffset>
                  <spirit:bitWidth>4</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>response_timeout_cnt</spirit:name>
                  <spirit:description>Response timer value</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>17</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000000000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004704</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>aux_ctrl1</spirit:name>
               <spirit:description>Aux control 1</spirit:description>
               <spirit:addressOffset>0x8</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0xC8009600</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>reply_timer</spirit:name>
                  <spirit:description>400us response timer setting in 0.0625 us step</spirit:description>
                  <spirit:bitOffset>19</spirit:bitOffset>
                  <spirit:bitWidth>13</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>1100100000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>response_timer</spirit:name>
                  <spirit:description>300us response timer setting in 0.0625 us step</spirit:description>
                  <spirit:bitOffset>3</spirit:bitOffset>
                  <spirit:bitWidth>13</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>1001011000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004708</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>aux_ctrl2</spirit:name>
               <spirit:description>Aux control 2</spirit:description>
               <spirit:addressOffset>0xC</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x001F0000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>pre_charge_length</spirit:name>
                  <spirit:description>Number of Zeroes in pre-charge period (register value + 1)</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>5</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>11111</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x8000470C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>aux_ctrl3</spirit:name>
               <spirit:description>Aux control 3</spirit:description>
               <spirit:addressOffset>0x10</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x0000004B</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>dp_aux_hpd_clk_freq</spirit:name>
                  <spirit:description>DP Aux and Hpd clock frequency in Mhz</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>01001011</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004710</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>aux_rx</spirit:name>
               <spirit:description>Aux receiver data and flag register</spirit:description>
               <spirit:addressOffset>0x14</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>rx_flag</spirit:name>
                  <spirit:description>High in EOP cycle</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>rx_data</spirit:name>
                  <spirit:description>aux received data</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                     <ids_properties>
                        <rtl.hw_rp>1</rtl.hw_rp>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004714</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>aux_tx</spirit:name>
               <spirit:description>Aux transmitter data and flag register</spirit:description>
               <spirit:addressOffset>0x18</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>go_bit</spirit:name>
                  <spirit:description>Set high to assert aux go_bit (source or sink)</spirit:description>
                  <spirit:bitOffset>9</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                     <ids_properties>
                        <rtl.hw_clear>1</rtl.hw_clear>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>tx_flag</spirit:name>
                  <spirit:description>High in EOP cycle</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>write-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>tx_data</spirit:name>
                  <spirit:description>aux transmit data</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>write-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                     <ids_properties>
                        <rtl.hw_wp>1</rtl.hw_wp>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004718</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>hpd_status</spirit:name>
               <spirit:description>Error bits for source/sink and misc status bits</spirit:description>
               <spirit:addressOffset>0x1C</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>hpd_line_out</spirit:name>
                  <spirit:description>HPD line out status</spirit:description>
                  <spirit:bitOffset>2</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>hpd_line_in_debounce</spirit:name>
                  <spirit:description>HPD line in after de-bouncing status</spirit:description>
                  <spirit:bitOffset>1</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>hpd_line_in</spirit:name>
                  <spirit:description>HPD line in status</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x8000471C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>hpd_ctrl</spirit:name>
               <spirit:description>HPD generator control bits</spirit:description>
               <spirit:addressOffset>0x20</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>hpd_low</spirit:name>
                  <spirit:description>Set high to generate LOW on HPD</spirit:description>
                  <spirit:bitOffset>3</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                     <ids_properties>
                        <rtl.hw_clear>1</rtl.hw_clear>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>hpd_high</spirit:name>
                  <spirit:description>Set high to generate HIGH on HPD</spirit:description>
                  <spirit:bitOffset>2</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                     <ids_properties>
                        <rtl.hw_clear>1</rtl.hw_clear>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>hpd_replug</spirit:name>
                  <spirit:description>Set high to generate a long pulse on HPD</spirit:description>
                  <spirit:bitOffset>1</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                     <ids_properties>
                        <rtl.hw_clear>1</rtl.hw_clear>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>hpd_irq</spirit:name>
                  <spirit:description>Set high to generate IRQ pulse on HPD</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                     <ids_properties>
                        <rtl.hw_clear>1</rtl.hw_clear>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004720</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>hpd_timer1</spirit:name>
               <spirit:description>Aux control</spirit:description>
               <spirit:addressOffset>0x24</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x0000200C</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>hpd_irq_to_irq_min_gap</spirit:name>
                  <spirit:description>2048 us hpd_irq to hpd_irq minimum gap setting in 64 us step step (spec indicates minimum of 2ms)</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>6</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>100000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>hpd_irq_pulse_width</spirit:name>
                  <spirit:description>768 us hpd_irq pulse setting in 64 us step (spec indicates 0.5ms to 1ms)</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>4</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>1100</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004724</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>hpd_timer2</spirit:name>
               <spirit:description>Aux control</spirit:description>
               <spirit:addressOffset>0x28</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x0000009C</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>hpd_replug_pulse_width</spirit:name>
                  <spirit:description>9.984us hpd_replug pulse setting in 64 us step (spec indicates 2ms to 100ms)</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>10011100</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004728</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>hpd_timer3</spirit:name>
               <spirit:description>Aux control</spirit:description>
               <spirit:addressOffset>0x2C</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x001F461A</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>hpd_irq_rising_detect</spirit:name>
                  <spirit:description>Rising pulse 2ms detection of hpd_irq (in 64us steps)</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>6</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>011111</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>hpd_irq_falling_detect</spirit:name>
                  <spirit:description>Falling pulse 0.25ms detection of hpd_irq (in 64us steps)</spirit:description>
                  <spirit:bitOffset>12</spirit:bitOffset>
                  <spirit:bitWidth>4</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0100</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>hpd_aux_debounce_period</spirit:name>
                  <spirit:description>De-bounce period of 100ms for hpd and aux sense signals (in 64us steps)</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>11</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>11000011010</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x8000472C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>hpd_rise_det</spirit:name>
               <spirit:description>HPD line falling edge counter logic</spirit:description>
               <spirit:addressOffset>0x30</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>cnt</spirit:name>
                  <spirit:description>Count value. It saturates at 8'd255.</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>rst</spirit:name>
                  <spirit:description>Write 1 and then 0 to reset the counter.</spirit:description>
                  <spirit:bitOffset>4</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>ctrl</spirit:name>
                  <spirit:description>1'b1: Start counter
1'b0: Stop counter</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004730</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>hpd_fall_det</spirit:name>
               <spirit:description>HPD line falling edge counter logic</spirit:description>
               <spirit:addressOffset>0x34</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>cnt</spirit:name>
                  <spirit:description>Count value. It saturates at 8'd255.</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>rst</spirit:name>
                  <spirit:description>Write 1 and then 0 to reset the counter.</spirit:description>
                  <spirit:bitOffset>4</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>ctrl</spirit:name>
                  <spirit:description>1'b1: Start counter
1'b0: Stop counter</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004734</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>dp_source_connect_det</spirit:name>
               <spirit:description>DP source connect detect counter logic</spirit:description>
               <spirit:addressOffset>0x38</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>cnt</spirit:name>
                  <spirit:description>Count value. It saturates at 8'd255.</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>rst</spirit:name>
                  <spirit:description>Write 1 and then 0 to reset the counter.</spirit:description>
                  <spirit:bitOffset>4</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>ctrl</spirit:name>
                  <spirit:description>1'b1: Start counter
1'b0: Stop counter</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004738</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>dp_source_disconnect_det</spirit:name>
               <spirit:description>DP source disconnect detect counter logic</spirit:description>
               <spirit:addressOffset>0x3C</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>cnt</spirit:name>
                  <spirit:description>Count value. It saturates at 8'd255.</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>rst</spirit:name>
                  <spirit:description>Write 1 and then 0 to reset the counter.</spirit:description>
                  <spirit:bitOffset>4</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>ctrl</spirit:name>
                  <spirit:description>1'b1: Start counter
1'b0: Stop counter</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x8000473C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>
  <!-- reg group
                    :irq  --> 
          <spirit:registerFile>
               <spirit:name>irq</spirit:name>
               <spirit:description>aux_hpd Interrupt register group</spirit:description>
               <spirit:addressOffset>0x40</spirit:addressOffset>
               <spirit:range>0x10</spirit:range>            
               <spirit:register>
                  <spirit:name>enable</spirit:name>
                  <spirit:description>Interrupt Enable register - Write 1 to enable, 0 to mask an interrupt
</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>dp_source_connect_det</spirit:name>
                     <spirit:description>Set high to enable dp_source_connect_det interrupt</spirit:description>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_source_disconnect_det</spirit:name>
                     <spirit:description>Set high to enable dp_source_disconnect_det interrupt</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_rise_det</spirit:name>
                     <spirit:description>Set high to enable hpd_rise_det interrupt</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_fall_det</spirit:name>
                     <spirit:description>Set high to enable hpd_fall_det interrupt</spirit:description>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_source_powered</spirit:name>
                     <spirit:description>Set high to enable dp_source_powered interrupt</spirit:description>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_source_detected</spirit:name>
                     <spirit:description>Set high to enable dp_source_detected interrupt</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_disconnect</spirit:name>
                     <spirit:description>Set high to enable hpd_disconnect interrupt</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_connect</spirit:name>
                     <spirit:description>Set high to enable hpd_connect interrupt</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_irq</spirit:name>
                     <spirit:description>Set high to enable hpd_irq interrupt</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_replug</spirit:name>
                     <spirit:description>Set high to enable hpd_replug interrupt</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_fifo_overflow</spirit:name>
                     <spirit:description>Set high to enable rx_fifo_overflow</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>reply_timeout</spirit:name>
                     <spirit:description>Set high to enable reply timeout interrupt</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>defer_sent</spirit:name>
                     <spirit:description>Set high to enable defer_sent interrupt</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>go_bit_clear</spirit:name>
                     <spirit:description>Set high to enable go_bit_clear interrupt</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_fifo_pkt_received</spirit:name>
                     <spirit:description>Set high to enable rx_fifo_pkt_received interrupt</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004740</address>
                        <intr.enable>irq0_dp_sink_aux_hpd</intr.enable>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending</spirit:name>
                  <spirit:description>Interrupt Pending register - This indicates which enabled interrupts have triggered, Write 1 to clear
</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>dp_source_connect_det</spirit:name>
                     <spirit:description>Registered dp_source_connect_det</spirit:description>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_source_disconnect_det</spirit:name>
                     <spirit:description>Registered dp_source_disconnect_det</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_rise_det</spirit:name>
                     <spirit:description>Registered hpd_rise_det</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_fall_det</spirit:name>
                     <spirit:description>Registered hpd_fall_det</spirit:description>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_source_powered</spirit:name>
                     <spirit:description>Registered dp_source_powered</spirit:description>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_source_detected</spirit:name>
                     <spirit:description>Registered dp_source_detected</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_disconnect</spirit:name>
                     <spirit:description>Registered hpd_disconnect</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_connect</spirit:name>
                     <spirit:description>Registered hpd_connect</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_irq</spirit:name>
                     <spirit:description>Registered hpd_irq</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_replug</spirit:name>
                     <spirit:description>Registered hpd_replug</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_fifo_overflow</spirit:name>
                     <spirit:description>Registered rx_fifo_overflow</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>reply_timeout</spirit:name>
                     <spirit:description>Registered reply timeout</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>defer_sent</spirit:name>
                     <spirit:description>Registered defer_sent</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>go_bit_clear</spirit:name>
                     <spirit:description>Registered go_bit_clear</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_fifo_pkt_received</spirit:name>
                     <spirit:description>Registered rx_fifo_pkt_received</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004744</address>
                        <intr.status>irq0_dp_sink_aux_hpd</intr.status>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending_irq</spirit:name>
                  <spirit:description>Interrupt Pending register - This indicates which enabled interrupts have triggered, Write 1 to clear
</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>dp_source_connect_det</spirit:name>
                     <spirit:description>Registered dp_source_connect_det</spirit:description>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_source_disconnect_det</spirit:name>
                     <spirit:description>Registered dp_source_disconnect_det</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_rise_det</spirit:name>
                     <spirit:description>Registered hpd_rise_det</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_fall_det</spirit:name>
                     <spirit:description>Registered hpd_fall_det</spirit:description>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_source_powered</spirit:name>
                     <spirit:description>Registered dp_source_powered</spirit:description>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_source_detected</spirit:name>
                     <spirit:description>Registered dp_source_detected</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_disconnect</spirit:name>
                     <spirit:description>Registered hpd_disconnect</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_connect</spirit:name>
                     <spirit:description>Registered hpd_connect</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_irq</spirit:name>
                     <spirit:description>Registered hpd_irq</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_replug</spirit:name>
                     <spirit:description>Registered hpd_replug</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_fifo_overflow</spirit:name>
                     <spirit:description>Registered rx_fifo_overflow</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>reply_timeout</spirit:name>
                     <spirit:description>Registered reply timeout</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>defer_sent</spirit:name>
                     <spirit:description>Registered defer_sent</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>go_bit_clear</spirit:name>
                     <spirit:description>Registered go_bit_clear</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_fifo_pkt_received</spirit:name>
                     <spirit:description>Registered rx_fifo_pkt_received</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004748</address>
                        <intr.pending>irq0_dp_sink_aux_hpd</intr.pending>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>raw</spirit:name>
                  <spirit:description>This register contains the registered state of interrupt signals</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>dp_source_connect_det</spirit:name>
                     <spirit:description>Current status of dp_source_connect_det</spirit:description>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_source_disconnect_det</spirit:name>
                     <spirit:description>Current status of dp_source_disconnect_det</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_rise_det</spirit:name>
                     <spirit:description>Current status of hpd_rise_det</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_fall_det</spirit:name>
                     <spirit:description>Current status of hpd_fall_det</spirit:description>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_source_powered</spirit:name>
                     <spirit:description>Current status of dp_source_powered</spirit:description>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_source_detected</spirit:name>
                     <spirit:description>Current status of dp_source_detected</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_disconnect</spirit:name>
                     <spirit:description>Current status of hpd_disconnect</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_connect</spirit:name>
                     <spirit:description>Current status of hpd_connect</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_irq</spirit:name>
                     <spirit:description>Current status of hpd_irq</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_replug</spirit:name>
                     <spirit:description>Current status of hpd_replug</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_fifo_overflow</spirit:name>
                     <spirit:description>Current status of rx_fifo_overflow</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>reply_timeout</spirit:name>
                     <spirit:description>Current status of reply timeout</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>defer_sent</spirit:name>
                     <spirit:description>Current status of defer_sent</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>go_bit_clear</spirit:name>
                     <spirit:description>Current status of go_bit_clear</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_fifo_pkt_received</spirit:name>
                     <spirit:description>Current status of rx_fifo_pkt_received</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000474C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004740</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : irq  --> 
         <spirit:vendorExtensions>
               <ids_properties>
                  <module_name>dp_aux_hpd_regs</module_name>
                  <uvm.package>dp_aux_hpd_regs_pkg</uvm.package>
                  <reset_type>async</reset_type>
                  <cheader.mask_endianess>little</cheader.mask_endianess>
                  <explicit_name>true</explicit_name>
                  <header.struct_guard>__ASSEMBLER__</header.struct_guard>
                  <vertical_reuse>true</vertical_reuse>
                  <address>0x80004700</address>
               </ids_properties>
            </spirit:vendorExtensions>
         </spirit:addressBlock>     
         <spirit:addressBlock>     
            <spirit:name>dp_source_main</spirit:name>
            <spirit:description>DP Source
</spirit:description>  <!-- //
                        block : dp_source_main  --> 
            <spirit:baseAddress>0x80004800</spirit:baseAddress>               
            <spirit:range>0x200</spirit:range>               
            <spirit:width>32</spirit:width>            
            <spirit:register>
               <spirit:name>version</spirit:name>
               <spirit:description>Version</spirit:description>
               <spirit:addressOffset>0x0</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x000B0900</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>major</spirit:name>
                  <spirit:description>Major version</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00001011</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>minor</spirit:name>
                  <spirit:description>Minor version</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00001001</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>patch</spirit:name>
                  <spirit:description>Patch version</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004800</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>configuration</spirit:name>
               <spirit:description>General configuration</spirit:description>
               <spirit:addressOffset>0x4</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00001043</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>debug_sel</spirit:name>
                  <spirit:description>Misc debug bits</spirit:description>
                  <spirit:bitOffset>28</spirit:bitOffset>
                  <spirit:bitWidth>4</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>dp_training_done</spirit:name>
                  <spirit:description>DP training is completed</spirit:description>
                  <spirit:bitOffset>24</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>vid_stream_end</spirit:name>
                  <spirit:description>The video stream is ended</spirit:description>
                  <spirit:bitOffset>17</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>apb_to_axi_mode_select</spirit:name>
                  <spirit:description>APB to AXI read mode select
1'b1: The read cycle is at least one clock later than read address cycle
1'b0: The read cycle happens at the same cycle as read address cycle</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>pix_gen_mode</spirit:name>
                  <spirit:description>Pixel generator mode select
2'b00: black 
2'b01: white
2'b10: Gray
2'b11: dark gray</spirit:description>
                  <spirit:bitOffset>14</spirit:bitOffset>
                  <spirit:bitWidth>2</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>pix_gen_sel</spirit:name>
                  <spirit:description>Select pixel generator as input to stream generator
0: Input from IntoPix decoder
1:Input from pixel generator</spirit:description>
                  <spirit:bitOffset>13</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>dp_enh_frm_en</spirit:name>
                  <spirit:description>DP enhanced framing mode enable. The enhanced mode is enabled when this bit is set to 1.</spirit:description>
                  <spirit:bitOffset>12</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>1</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>decoder_error_inject</spirit:name>
                  <spirit:description>Write 1 to inject a cycle of random error.</spirit:description>
                  <spirit:bitOffset>11</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>vid_stream_generator_en</spirit:name>
                  <spirit:description>Enable video related logic in stream_generator module</spirit:description>
                  <spirit:bitOffset>10</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>syn_stream_generator_en</spirit:name>
                  <spirit:description>Enable DP stream synthesize related logic in stream_generator module</spirit:description>
                  <spirit:bitOffset>9</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>sdp_en</spirit:name>
                  <spirit:description>SDP enable. The SDP function is enabled when it is 1</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>lane_bit_rate</spirit:name>
                  <spirit:description>DP serial bit rate
2'b00: RBR (1.62 Gbps)
2'b01: HBR (2.70 Gbps)
2'b10: HBR2 (5.40 Gbps)
2'b11: HBR3(8.10 Gbps)</spirit:description>
                  <spirit:bitOffset>6</spirit:bitOffset>
                  <spirit:bitWidth>2</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>01</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>tps_sel</spirit:name>
                  <spirit:description>Training pattern selection
4'd0: TPS0 (No test pattern. DP functional mode
4'd1: TPS1
4'd2: TPS2
4'd3: TPS3
4'd4: CP2520 pattern 1
4'd5: CP2520 pattern 2-
4'd6: CP2520 pattern 2+
4'd7: CP2520 pattern 3 (Also called TPS4)
4'd8: Custom 80-bit pattern</spirit:description>
                  <spirit:bitOffset>2</spirit:bitOffset>
                  <spirit:bitWidth>4</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>lane_num</spirit:name>
                  <spirit:description>Number of active dp lanes
2'b00: 1 lane
2'b01: 2 lanes
2'b10: Invalid
2'b11: 4 lanes</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>2</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>11</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004804</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>scrambler</spirit:name>
               <spirit:addressOffset>0x8</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>enable</spirit:name>
                  <spirit:description>Scrambler enable bit. The scrambler is enabled when this bit is set to 1. The scrambler is bypassed when this bit is set to 0</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004808</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>
  <!-- reg group
                    :stream_generator  --> 
          <spirit:registerFile>
               <spirit:name>stream_generator</spirit:name>
               <spirit:addressOffset>0xC</spirit:addressOffset>
               <spirit:range>0x9C</spirit:range>            
               <spirit:register>
                  <spirit:name>cfg0</spirit:name>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x3E85A200</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>cs_start_level</spirit:name>
                     <spirit:description>The level cs buffer needs to filled before is read</spirit:description>
                     <spirit:bitOffset>20</spirit:bitOffset>
                     <spirit:bitWidth>12</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>001111101000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>cs_pkt_length</spirit:name>
                     <spirit:description>The length of code stream packet</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>10</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0101101000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>pix_start_level</spirit:name>
                     <spirit:description>The level elasticity buffer needs to filled before is read</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>10</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000480C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>cfg1</spirit:name>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x000143F4</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>cs_fifo_level_check_frequency</spirit:name>
                     <spirit:description>The frequency of allowing CS packet interval to be updated. The unit is number of lines. It is applicable if "cs_pkt_interval_feedback_ctrl_debug" is set to 1 otherwise the update occurs at every line.</spirit:description>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>10</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000001010</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>cs_pkt_interval</spirit:name>
                     <spirit:description>The average interval of cs packets</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>13</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0001111110100</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004810</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>cfg2</spirit:name>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000011</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>cs_pkt_interval_feedback_ctrl</spirit:name>
                     <spirit:description>CS packet interval feedback control
1'b0: Use cs_pkt_interval register as input to negative feedback logic
1'b1: Use previous latched value as input to negative feedback logic</spirit:description>
                     <spirit:bitOffset>31</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>cs_pkt_interval_feedback_ctrl_debug</spirit:name>
                     <spirit:description>CS packet interval feedback control
debug bits</spirit:description>
                     <spirit:bitOffset>27</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>cs_pkt_interval_minus_offset0</spirit:name>
                     <spirit:description>CS packet interval minus offset 0</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0001</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>cs_pkt_interval_plus_offset0</spirit:name>
                     <spirit:description>CS packet interval plus offset 0</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0001</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004814</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>cfg3</spirit:name>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00008844</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>dp_width_total_feedback_ctrl</spirit:name>
                     <spirit:description>DP width feedback control
1'b0: Use dp_width_total register as input to negative feedback logic
1'b1: Use previous latched value as input to negative feedback logic</spirit:description>
                     <spirit:bitOffset>31</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_width_total_feedback_ctrl_debug</spirit:name>
                     <spirit:description>DP width feedback control debug bits</spirit:description>
                     <spirit:bitOffset>27</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_width_total_minus_offset1</spirit:name>
                     <spirit:description>DP total width minus offset 1 used when read and write rates are within the</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_width_total_plus_offset1</spirit:name>
                     <spirit:description>DP total width plus offset 1</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_width_total_minus_offset0</spirit:name>
                     <spirit:description>DP total width minus offset 0</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0100</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_width_total_plus_offset0</spirit:name>
                     <spirit:description>DP total width plus offset 0</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>4</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0100</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004818</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>cs_pkt_updated_interval</spirit:name>
                  <spirit:addressOffset>0x10</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>debug</spirit:name>
                     <spirit:description>CS packet updated interval</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>13</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000481C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>dp_width_total_actual</spirit:name>
                  <spirit:addressOffset>0x14</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>debug</spirit:name>
                     <spirit:description>DP actual total width</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>15</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004820</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>alu0</spirit:name>
                  <spirit:addressOffset>0x18</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x0DA40FA0</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>dp_width_active</spirit:name>
                     <spirit:description>Active region DP width per lane in symbol</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>15</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000110110100100</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_width_total</spirit:name>
                     <spirit:description>Total DP width per lane in symbol</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>15</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000111110100000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004824</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>alu1</spirit:name>
                  <spirit:addressOffset>0x1C</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00404836</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>full_tu_size</spirit:name>
                     <spirit:description>Full TU size</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>7</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>last_tu_size</spirit:name>
                     <spirit:description>Last TU size</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>7</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0100100</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>full_tu_num</spirit:name>
                     <spirit:description>Number of full TU units</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>9</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000110110</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004828</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>alu2</spirit:name>
                  <spirit:addressOffset>0x20</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x000D05A0</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>cpu_math_result_rdy</spirit:name>
                     <spirit:description>CPU calculation results are ready</spirit:description>
                     <spirit:bitOffset>31</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                        <ids_properties>
                           <rtl.hw_clear>1</rtl.hw_clear>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>valid_bytes_repeat_num</spirit:name>
                     <spirit:description>Number of TUs with valid bytes per full TU before increment by one</spirit:description>
                     <spirit:bitOffset>22</spirit:bitOffset>
                     <spirit:bitWidth>9</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>valid_bytes_per_full_tu</spirit:name>
                     <spirit:description>Number of valid bytes in one transfer unit per lane</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>7</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0011010</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>valid_bytes_num_per_lane</spirit:name>
                     <spirit:description>Number of valid bytes per lane per line</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>15</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000010110100000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000482C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
  <!-- reg group
                    :msa  --> 
          <spirit:registerFile>
                  <spirit:name>msa</spirit:name>
                  <spirit:addressOffset>0x24</spirit:addressOffset>
                  <spirit:range>0x24</spirit:range>            
                  <spirit:register>
                     <spirit:name>control_0</spirit:name>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00004666</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>nvid_sel</spirit:name>
                        <spirit:description>DP stream NVID sel
1: Use nvid_set_value register 
0: Use nvid in the MSA packet sent by LEX</spirit:description>
                        <spirit:bitOffset>26</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>mvid_sel</spirit:name>
                        <spirit:description>DP stream MVID sel
2'b00: : Use measured value with mvid in the MSA packet sent by LEX for the initial value 
2'b01: Use mvid_set_value register 
2'b10: Use measured value with mvid_set_value register for the initial value.
2'b11: use mvid in the MSA packet sent by LEX</spirit:description>
                        <spirit:bitOffset>24</spirit:bitOffset>
                        <spirit:bitWidth>2</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>mvid_set_value</spirit:name>
                        <spirit:description>mvid set value when msa_mvid_sel is 2'b01</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>24</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>000000000100011001100110</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004830</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>control_1</spirit:name>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00008000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>insert_line_sel</spirit:name>
                        <spirit:description>Vertical blanking line selection for MSA insertion</spirit:description>
                        <spirit:bitOffset>24</spirit:bitOffset>
                        <spirit:bitWidth>8</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>nvid_set_value</spirit:name>
                        <spirit:description>nvid set value when msa_nvid_sel is 1'b0</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>24</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>000000001000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004834</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>mvid</spirit:name>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>mvid</spirit:name>
                        <spirit:description>msa mvid value</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>24</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004838</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>nvid</spirit:name>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>nvid</spirit:name>
                        <spirit:description>msa nvid value</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>24</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x8000483C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>horizontal_0</spirit:name>
                     <spirit:addressOffset>0x10</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x0FA00036</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>total</spirit:name>
                        <spirit:description>msa h total</spirit:description>
                        <spirit:bitOffset>16</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000111110100000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>start</spirit:name>
                        <spirit:description>msa h start</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000110110</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004840</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>horizontal_1</spirit:name>
                     <spirit:addressOffset>0x14</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x0F000020</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>width</spirit:name>
                        <spirit:description>msa h width</spirit:description>
                        <spirit:bitOffset>16</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000111100000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>polarity</spirit:name>
                        <spirit:description>msa h sync polarity (hsp)</spirit:description>
                        <spirit:bitOffset>15</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>sync_width</spirit:name>
                        <spirit:description>msa h sync width (hsw)</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>15</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>000000000100000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004844</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>vertical_0</spirit:name>
                     <spirit:addressOffset>0x18</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x08AE0050</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>total</spirit:name>
                        <spirit:description>msa v total</spirit:description>
                        <spirit:bitOffset>16</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000100010101110</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>start</spirit:name>
                        <spirit:description>msa v start</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000001010000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004848</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>vertical_1</spirit:name>
                     <spirit:addressOffset>0x1C</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x08700005</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>height</spirit:name>
                        <spirit:description>msa v height</spirit:description>
                        <spirit:bitOffset>16</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000100001110000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>polarity</spirit:name>
                        <spirit:description>msa v sync polarity (vsp)</spirit:description>
                        <spirit:bitOffset>15</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>sync_width</spirit:name>
                        <spirit:description>msa v sync width (vsw)</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>15</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>000000000000101</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x8000484C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>misc</spirit:name>
                     <spirit:addressOffset>0x20</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000020</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>reserved</spirit:name>
                        <spirit:description>msa misc_1 bits 5:3 field for reseved bits</spirit:description>
                        <spirit:bitOffset>16</spirit:bitOffset>
                        <spirit:bitWidth>3</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>vsc_sdp</spirit:name>
                        <spirit:description>msa misc_1 bit 6 field</spirit:description>
                        <spirit:bitOffset>12</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>y_only</spirit:name>
                        <spirit:description>msa misc_1 bit 7 field for Y-only and Raw video</spirit:description>
                        <spirit:bitOffset>11</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>stereo</spirit:name>
                        <spirit:description>msa misc_1 bits 2:1 field for Stereo video attribute
0 = No 3D video</spirit:description>
                        <spirit:bitOffset>9</spirit:bitOffset>
                        <spirit:bitWidth>2</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>00</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>int_total</spirit:name>
                        <spirit:description>msa misc_1 bit 0 field for interlaced video</spirit:description>
                        <spirit:bitOffset>8</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>color</spirit:name>
                        <spirit:description>msa misc_0 bits 7:1 for the Colorimetry field
See DP 1.2 page 78
0x00 = RGB 18bpp
0x10 = RGB 24bpp
0x20 = RGB 30bpp
0x30 = RGB 36bpp
0x40 = RGB 48bpp</spirit:description>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>7</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0010000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>clk_sync</spirit:name>
                        <spirit:description>msa misc_0 bit 0 for synchronous clock.
0 = Link and main video clock are asynchronous
1 = Link and main video clock are synchronous</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004850</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004830</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : msa  --> 

  <!-- reg group
                    :msa_dp  --> 
          <spirit:registerFile>
                  <spirit:name>msa_dp</spirit:name>
                  <spirit:addressOffset>0x48</spirit:addressOffset>
                  <spirit:range>0x8</spirit:range>            
                  <spirit:register>
                     <spirit:name>mvid</spirit:name>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>mvid</spirit:name>
                        <spirit:description>Msa MVID value plugged into DP stream</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>24</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004854</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>nvid</spirit:name>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>nvid</spirit:name>
                        <spirit:description>Msa NVID value plugged into DP stream</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>24</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>000000000000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004858</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004854</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : msa_dp  --> 
            <spirit:register>
                  <spirit:name>fsm_status</spirit:name>
                  <spirit:description>Stream generator module cs FIFO status register</spirit:description>
                  <spirit:addressOffset>0x50</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>state_vid</spirit:name>
                     <spirit:description>state_vid
00: e_idle
01: e_vs
10: e_dummy
11: N/A</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>2</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>state_dp</spirit:name>
                     <spirit:description>state_dp
00: e_wait
01: e_idle_pattern
10: e_video
11: N/A</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>2</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000485C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_cs_level</spirit:name>
                  <spirit:addressOffset>0x54</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>level</spirit:name>
                     <spirit:description>Raw FIFO level</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004860</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_cs_status</spirit:name>
                  <spirit:description>Stream generator module cs FIFO status register</spirit:description>
                  <spirit:addressOffset>0x58</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x000000A1</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>ae1</spirit:name>
                     <spirit:description>FIFO almost empty 1 status. A "1" indicates an almost empty or empty FIFO. The threshold level is set by aet1 field.</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>af1</spirit:name>
                     <spirit:description>FIFO almost full 1 status. A "1" indicates an almost full or full FIFO.
The threshold level is set by aft1 field.</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>ae0</spirit:name>
                     <spirit:description>FIFO almost empty 0 status. A "1" indicates an almost empty or empty FIFO. The threshold level is set by aet0 field.</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>af0</spirit:name>
                     <spirit:description>FIFO almost full 0 status. A "1" indicates an almost full or full FIFO.
The threshold level is set by aft0 field.</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>overflow</spirit:name>
                     <spirit:description>FIFO overflow status. A "1" indicates overflow in FIFO.</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>underflow</spirit:name>
                     <spirit:description>FIFO underflow status. A "1" indicates underflow in FIFO.</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>full</spirit:name>
                     <spirit:description>FIFO full status. A "1" indicates FIFO is full</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>empty</spirit:name>
                     <spirit:description>FIFO empty status. A "1" indicates FIFO is empty</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004864</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_cs_control0</spirit:name>
                  <spirit:description>FIFO threshold level controls set0</spirit:description>
                  <spirit:addressOffset>0x5C</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x01680168</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>aet0</spirit:name>
                     <spirit:description>FIFO almost empty 0 threshold setting. If FIFO level is equal or below this threshold then ae0 goes high</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000101101000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>aft0</spirit:name>
                     <spirit:description>FIFO almost full 0 threshold setting. If FIFO level is equal or above this threshold then af0 goes high</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000101101000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004868</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_cs_control1</spirit:name>
                  <spirit:description>FIFO threshold level controls set 1</spirit:description>
                  <spirit:addressOffset>0x60</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x021C021C</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>aet1</spirit:name>
                     <spirit:description>FIFO almost empty 1 threshold setting. If FIFO level is equal or below this threshold then ae1 goes high</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000001000011100</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>aft1</spirit:name>
                     <spirit:description>FIFO almost full 1 threshold setting. If FIFO level is equal or above this threshold then af1 goes high</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000001000011100</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000486C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_cs_config</spirit:name>
                  <spirit:addressOffset>0x64</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>depth</spirit:name>
                     <spirit:description>FIFO depth. This value is used for the build</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004870</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_pix_level</spirit:name>
                  <spirit:addressOffset>0x68</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>level</spirit:name>
                     <spirit:description>Raw FIFO level</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004874</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_pix_sr_status</spirit:name>
                  <spirit:description>Packetizer module FIFO status register</spirit:description>
                  <spirit:addressOffset>0x6C</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000001</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>sr_0_underflow</spirit:name>
                     <spirit:description>SR 0 underflow status. A "1" indicates underflow in SR.</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sr_1_underflow</spirit:name>
                     <spirit:description>SR 1 underflow status. A "1" indicates underflow in SR.</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sr_2_underflow</spirit:name>
                     <spirit:description>SR 2 underflow status. A "1" indicates underflow in SR.</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>sr_3_underflow</spirit:name>
                     <spirit:description>SR 3 underflow status. A "1" indicates underflow in SR.</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_0_ae1</spirit:name>
                     <spirit:description>FIFO almost empty 1 status. A "1" indicates an almost empty or empty FIFO. The threshold level is set by aet1 field.</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_0_af1</spirit:name>
                     <spirit:description>FIFO almost full 1 status. A "1" indicates an almost full or full FIFO.
The threshold level is set by aft1 field.</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_0_ae0</spirit:name>
                     <spirit:description>FIFO almost empty 1 status. A "1" indicates an almost empty or empty FIFO. The threshold level is set by aet0 field.</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_0_af0</spirit:name>
                     <spirit:description>FIFO almost full 1 status. A "1" indicates an almost full or full FIFO.
The threshold level is set by aft0 field.</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_0_overflow</spirit:name>
                     <spirit:description>FIFO 0 overflow status. A "1" indicates overflow in FIFO.</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_0_underflow</spirit:name>
                     <spirit:description>FIFO 0 underflow status. A "1" indicates underflow in FIFO.</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_0_full</spirit:name>
                     <spirit:description>FIFO 0 full status. A "1" indicates FIFO is full</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_0_empty</spirit:name>
                     <spirit:description>FIFO 0 empty status. A "1" indicates FIFO is empty</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004878</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_pix_control0</spirit:name>
                  <spirit:description>FIFO threshold level controls set0</spirit:description>
                  <spirit:addressOffset>0x70</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x08000800</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>aet0</spirit:name>
                     <spirit:description>FIFO almost empty 0 threshold setting. If FIFO level is equal or below this threshold then ae0 goes high</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000100000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>aft0</spirit:name>
                     <spirit:description>FIFO almost full 0 threshold setting. If FIFO level is equal or above this threshold then af0 goes high</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000100000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000487C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_pix_control1</spirit:name>
                  <spirit:description>FIFO threshold level controls set 1</spirit:description>
                  <spirit:addressOffset>0x74</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x04000400</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>aet1</spirit:name>
                     <spirit:description>FIFO almost empty 1 threshold setting. If FIFO level is equal or below this threshold then ae1 goes high</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000010000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>aft1</spirit:name>
                     <spirit:description>FIFO almost full 1 threshold setting. If FIFO level is equal or above 
this threshold then af1 goes high</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000010000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004880</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_pix_control2</spirit:name>
                  <spirit:description>FIFO threshold level controls set 2</spirit:description>
                  <spirit:addressOffset>0x78</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>offset</spirit:name>
                     <spirit:description>The offset used to shift the threshold levels</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004884</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_pix_config</spirit:name>
                  <spirit:addressOffset>0x7C</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>depth</spirit:name>
                     <spirit:description>FIFO depth. This value is used for the build</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004888</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_sdp_status</spirit:name>
                  <spirit:description>SDP FIFO status register</spirit:description>
                  <spirit:addressOffset>0x80</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000001</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>overflow</spirit:name>
                     <spirit:description>FIFO overflow status. A "1" indicates overflow in FIFO.</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>underflow</spirit:name>
                     <spirit:description>FIFO underflow status. A "1" indicates underflow in FIFO.</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>full</spirit:name>
                     <spirit:description>FIFO full status. A "1" indicates FIFO is full</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>empty</spirit:name>
                     <spirit:description>FIFO empty status. A "1" indicates FIFO is empty</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000488C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_sdp_tag_status</spirit:name>
                  <spirit:description>SDP tag FIFO status register</spirit:description>
                  <spirit:addressOffset>0x84</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000001</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>overflow</spirit:name>
                     <spirit:description>FIFO overflow status. A "1" indicates overflow in FIFO.</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>underflow</spirit:name>
                     <spirit:description>FIFO underflow status. A "1" indicates underflow in FIFO.</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>full</spirit:name>
                     <spirit:description>FIFO full status. A "1" indicates FIFO is full</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>empty</spirit:name>
                     <spirit:description>FIFO empty status. A "1" indicates FIFO is empty</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004890</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_sdp_config</spirit:name>
                  <spirit:addressOffset>0x88</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>depth</spirit:name>
                     <spirit:description>FIFO depth. This value is used for the build</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>11</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004894</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_sdp_tag_config</spirit:name>
                  <spirit:addressOffset>0x8C</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>depth</spirit:name>
                     <spirit:description>FIFO depth. This value is used for the build</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>9</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004898</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>sdp_ctrl</spirit:name>
                  <spirit:addressOffset>0x90</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000001</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>maud_set_value</spirit:name>
                     <spirit:description>The manual value used for Maud</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>maud_method_sel</spirit:name>
                     <spirit:description>The maud setting method
0: Manual value
1: Extracted value from audio time stamp packet</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>audiomute_flag</spirit:name>
                     <spirit:description>The audiomute flag received from LEX</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>1</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000489C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>idle_pattern_debug</spirit:name>
                  <spirit:description>Debug</spirit:description>
                  <spirit:addressOffset>0x94</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>cnt</spirit:name>
                     <spirit:description>Idle pattern count</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>cnt_rst</spirit:name>
                     <spirit:description>Idle pattern count reset</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800048A0</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>vbd</spirit:name>
                  <spirit:addressOffset>0x98</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>vbid</spirit:name>
                     <spirit:description>vbid value</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>maud</spirit:name>
                     <spirit:description>maud value</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>mvid</spirit:name>
                     <spirit:description>Lower 8 bits of mvid[31:0]</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800048A4</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x8000480C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : stream_generator  --> 

  <!-- reg group
                    :decoder_error_status  --> 
          <spirit:registerFile>
               <spirit:name>decoder_error_status</spirit:name>
               <spirit:addressOffset>0xA8</spirit:addressOffset>
               <spirit:range>0x8</spirit:range>            
               <spirit:register>
                  <spirit:name>handshake</spirit:name>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>vfr_handshake</spirit:name>
                     <spirit:description>Number of images with a fault on handshake (vid_enbl='1' while vid_valid='0')</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>cfr_handshake</spirit:name>
                     <spirit:description>Number of images with a fault on handshake (cs_enbl='1' while cs_ready='0')</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800048A8</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>error_id</spirit:name>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>err_id</spirit:name>
                     <spirit:description>Error Identification when err_flag is set
First error identified in the current frame:
1-2 = internal error
3 = error on the codestream input interface
4 = error on the video output interface
5 = mismatch between codestream header config and video size config
6 = external abort</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>err_flag</spirit:name>
                     <spirit:description>Error detected during the processing of the current frame.</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800048AC</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x800048A8</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : decoder_error_status  --> 

  <!-- reg group
                    :compliance  --> 
          <spirit:registerFile>
               <spirit:name>compliance</spirit:name>
               <spirit:description>Compliance 80bit custom patten</spirit:description>
               <spirit:addressOffset>0xB0</spirit:addressOffset>
               <spirit:range>0xC</spirit:range>            
               <spirit:register>
                  <spirit:name>custom_80bits_3_0</spirit:name>
                  <spirit:description>Bytes 0 to 3</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>byte3</spirit:name>
                     <spirit:description>TEST_80BIT_CUSTOM_PATTERN Value 31:24</spirit:description>
                     <spirit:bitOffset>24</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>byte2</spirit:name>
                     <spirit:description>TEST_80BIT_CUSTOM_PATTERN Value 23:16</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>byte1</spirit:name>
                     <spirit:description>TEST_80BIT_CUSTOM_PATTERN Value 15:8</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>byte0</spirit:name>
                     <spirit:description>TEST_80BIT_CUSTOM_PATTERN Value 7:0</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800048B0</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>custom_80bits_7_4</spirit:name>
                  <spirit:description>Bytes 4 to 7</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>byte7</spirit:name>
                     <spirit:description>TEST_80BIT_CUSTOM_PATTERN Value 63:56</spirit:description>
                     <spirit:bitOffset>24</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>byte6</spirit:name>
                     <spirit:description>TEST_80BIT_CUSTOM_PATTERN Value 55:48</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>byte5</spirit:name>
                     <spirit:description>TEST_80BIT_CUSTOM_PATTERN Value 47:40</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>byte4</spirit:name>
                     <spirit:description>TEST_80BIT_CUSTOM_PATTERN Value 39:32</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800048B4</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>custom_80bits_9_8</spirit:name>
                  <spirit:description>Bytes 9 to 10</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>byte9</spirit:name>
                     <spirit:description>TEST_80BIT_CUSTOM_PATTERN Value 79:72</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>byte8</spirit:name>
                     <spirit:description>TEST_80BIT_CUSTOM_PATTERN Value 71:64</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x800048B8</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x800048B0</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : compliance  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
               <spirit:name>stats0</spirit:name>
               <spirit:description>All the Statistic Registers and their configuration.</spirit:description>
               <spirit:addressOffset>0xBC</spirit:addressOffset>
               <spirit:range>0x2C</spirit:range>            
               <spirit:register>
                  <spirit:name>rd2clr_config</spirit:name>
                  <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>fifo_pix_0_level_watermark</spirit:name>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_pix_0_level</spirit:name>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>pix_0_sr_underflow</spirit:name>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>pix_1_sr_underflow</spirit:name>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>pix_2_sr_underflow</spirit:name>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>pix_3_sr_underflow</spirit:name>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_pix_0_underflow</spirit:name>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_pix_0_overflow</spirit:name>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_pix_0_empty</spirit:name>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_pix_0_full</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x800048BC</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_pix_0_full</spirit:name>
                  <spirit:description>Pixel 0 FIFO full count</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>fifo_pix_0_full</spirit:name>
                     <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x800048C0</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_pix_0_empty</spirit:name>
                  <spirit:description>Pixel 0 FIFO empty count</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>fifo_pix_0_empty</spirit:name>
                     <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x800048C4</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_pix_0_overflow</spirit:name>
                  <spirit:description>Pixel 0 FIFO overflow count</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>fifo_pix_0_overflow</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x800048C8</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_pix_0_underflow</spirit:name>
                  <spirit:description>Pixel 0 FIFO underflow count</spirit:description>
                  <spirit:addressOffset>0x10</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>fifo_pix_0_underflow</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x800048CC</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pix_0_sr_underflow</spirit:name>
                  <spirit:description>Pixel 0 shift register underflow count</spirit:description>
                  <spirit:addressOffset>0x14</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>pix_0_sr_underflow</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x800048D0</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pix_1_sr_underflow</spirit:name>
                  <spirit:description>Pixel 1 shift register underflow count</spirit:description>
                  <spirit:addressOffset>0x18</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>pix_1_sr_underflow</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x800048D4</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pix_2_sr_underflow</spirit:name>
                  <spirit:description>Pixel 2 shift register underflow count</spirit:description>
                  <spirit:addressOffset>0x1C</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>pix_2_sr_underflow</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x800048D8</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pix_3_sr_underflow</spirit:name>
                  <spirit:description>Pixel 3 shift register underflow count</spirit:description>
                  <spirit:addressOffset>0x20</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>pix_3_sr_underflow</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x800048DC</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_pix_0_level</spirit:name>
                  <spirit:description>Pixel 0 FIFO level at beginning of DP frame</spirit:description>
                  <spirit:addressOffset>0x24</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>fifo_pix_0_level</spirit:name>
                     <spirit:description>_icron_no_counter_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x800048E0</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_pix_0_level_watermark</spirit:name>
                  <spirit:description>Pixel 0 FIFO level at beginning of DP frame (watermark)</spirit:description>
                  <spirit:addressOffset>0x28</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>fifo_pix_0_level_watermark</spirit:name>
                     <spirit:description>_icron_no_counter_;_icron_water_marker_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x800048E4</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x800048BC</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 

  <!-- reg group
                    :stats1  --> 
          <spirit:registerFile>
               <spirit:name>stats1</spirit:name>
               <spirit:description>All the Statistic Registers and their configuration.</spirit:description>
               <spirit:addressOffset>0xE8</spirit:addressOffset>
               <spirit:range>0x60</spirit:range>            
               <spirit:register>
                  <spirit:name>rd2clr_config</spirit:name>
                  <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>sdp_ptp_pkt_sop_in</spirit:name>
                     <spirit:bitOffset>22</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_sdp_tag_level_watermark</spirit:name>
                     <spirit:bitOffset>21</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_sdp_tag_level</spirit:name>
                     <spirit:bitOffset>20</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_sdp_tag_underflow</spirit:name>
                     <spirit:bitOffset>19</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_sdp_tag_overflow</spirit:name>
                     <spirit:bitOffset>18</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_sdp_tag_empty</spirit:name>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_sdp_tag_full</spirit:name>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_sdp_level_watermark</spirit:name>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_sdp_level</spirit:name>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_sdp_underflow</spirit:name>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_sdp_overflow</spirit:name>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_sdp_empty</spirit:name>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_sdp_full</spirit:name>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_cs_level_watermark</spirit:name>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_cs_level</spirit:name>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_cs_af1</spirit:name>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_cs_af0</spirit:name>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_cs_ae1</spirit:name>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_cs_ae0</spirit:name>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_cs_underflow</spirit:name>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_cs_overflow</spirit:name>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_cs_empty</spirit:name>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_cs_full</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x800048E8</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_cs_full</spirit:name>
                  <spirit:description>CS FIFO full count</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>fifo_cs_full</spirit:name>
                     <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x800048EC</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_cs_empty</spirit:name>
                  <spirit:description>CS FIFO empty count</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>fifo_cs_empty</spirit:name>
                     <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x800048F0</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_cs_overflow</spirit:name>
                  <spirit:description>CS FIFO overflow count</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>fifo_cs_overflow</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x800048F4</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_cs_underflow</spirit:name>
                  <spirit:description>CS FIFO underflow count</spirit:description>
                  <spirit:addressOffset>0x10</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>fifo_cs_underflow</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x800048F8</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_cs_ae0</spirit:name>
                  <spirit:description>CS FIFO almost empty threshold 0 count</spirit:description>
                  <spirit:addressOffset>0x14</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>fifo_cs_ae0</spirit:name>
                     <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x800048FC</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_cs_ae1</spirit:name>
                  <spirit:description>CS FIFO almost empty threshold 1 count</spirit:description>
                  <spirit:addressOffset>0x18</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>fifo_cs_ae1</spirit:name>
                     <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004900</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_cs_af0</spirit:name>
                  <spirit:description>CS FIFO almost full threshold 0 count</spirit:description>
                  <spirit:addressOffset>0x1C</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>fifo_cs_af0</spirit:name>
                     <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004904</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_cs_af1</spirit:name>
                  <spirit:description>CS FIFO almost full threshold 1 count</spirit:description>
                  <spirit:addressOffset>0x20</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>fifo_cs_af1</spirit:name>
                     <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004908</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_cs_level</spirit:name>
                  <spirit:description>CS FIFO level at beginning of DP frame</spirit:description>
                  <spirit:addressOffset>0x24</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>fifo_cs_level</spirit:name>
                     <spirit:description>_icron_no_counter_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x8000490C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_cs_level_watermark</spirit:name>
                  <spirit:description>CS FIFO level at beginning of DP frame (watermark)</spirit:description>
                  <spirit:addressOffset>0x28</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>fifo_cs_level_watermark</spirit:name>
                     <spirit:description>_icron_no_counter_;_icron_water_marker_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004910</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_sdp_full</spirit:name>
                  <spirit:description>SDP FIFO full count</spirit:description>
                  <spirit:addressOffset>0x2C</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>fifo_sdp_full</spirit:name>
                     <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004914</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_sdp_empty</spirit:name>
                  <spirit:description>SDP FIFO empty count</spirit:description>
                  <spirit:addressOffset>0x30</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>fifo_sdp_empty</spirit:name>
                     <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004918</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_sdp_overflow</spirit:name>
                  <spirit:description>SDP FIFO overflow count</spirit:description>
                  <spirit:addressOffset>0x34</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>fifo_sdp_overflow</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x8000491C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_sdp_underflow</spirit:name>
                  <spirit:description>SDP FIFO underflow count</spirit:description>
                  <spirit:addressOffset>0x38</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>fifo_sdp_underflow</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004920</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_sdp_level</spirit:name>
                  <spirit:description>SDP FIFO level</spirit:description>
                  <spirit:addressOffset>0x3C</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>fifo_sdp_level</spirit:name>
                     <spirit:description>_icron_no_counter_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004924</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_sdp_level_watermark</spirit:name>
                  <spirit:description>SDP FIFO level (watermark)</spirit:description>
                  <spirit:addressOffset>0x40</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>fifo_sdp_level_watermark</spirit:name>
                     <spirit:description>_icron_no_counter_;_icron_water_marker_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004928</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_sdp_tag_full</spirit:name>
                  <spirit:description>SDP tag FIFO full count</spirit:description>
                  <spirit:addressOffset>0x44</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>fifo_sdp_tag_full</spirit:name>
                     <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x8000492C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_sdp_tag_empty</spirit:name>
                  <spirit:description>SDP tag FIFO empty count</spirit:description>
                  <spirit:addressOffset>0x48</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>fifo_sdp_tag_empty</spirit:name>
                     <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004930</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_sdp_tag_overflow</spirit:name>
                  <spirit:description>SDP tag FIFO overflow count</spirit:description>
                  <spirit:addressOffset>0x4C</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>fifo_sdp_tag_overflow</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004934</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_sdp_tag_underflow</spirit:name>
                  <spirit:description>SDP tag FIFO underflow count</spirit:description>
                  <spirit:addressOffset>0x50</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>fifo_sdp_tag_underflow</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004938</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_sdp_tag_level</spirit:name>
                  <spirit:description>SDP tag FIFO level</spirit:description>
                  <spirit:addressOffset>0x54</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>fifo_sdp_tag_level</spirit:name>
                     <spirit:description>_icron_no_counter_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x8000493C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>fifo_sdp_tag_level_watermark</spirit:name>
                  <spirit:description>SDP tag FIFO level (watermark)</spirit:description>
                  <spirit:addressOffset>0x58</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>fifo_sdp_tag_level_watermark</spirit:name>
                     <spirit:description>_icron_no_counter_;_icron_water_marker_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004940</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>sdp_ptp_pkt_sop_in</spirit:name>
                  <spirit:description>SDP PTP packets received</spirit:description>
                  <spirit:addressOffset>0x5C</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>sdp_ptp_pkt_sop_in</spirit:name>
                     <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004944</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x800048E8</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : stats1  --> 

  <!-- reg group
                    :irq  --> 
          <spirit:registerFile>
               <spirit:name>irq</spirit:name>
               <spirit:description>source Interrupt register group</spirit:description>
               <spirit:addressOffset>0x148</spirit:addressOffset>
               <spirit:range>0x10</spirit:range>            
               <spirit:register>
                  <spirit:name>enable</spirit:name>
                  <spirit:description>Interrupt Enable register - Write 1 to enable, 0 to mask an interrupt
</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>msa_dp_mvid_measured_update</spirit:name>
                     <spirit:description>Set high to enable msa_dp_mvid_measured_update</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>first_idle_pattern_sent</spirit:name>
                     <spirit:description>Set high to enable first_idle_pattern_sent</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>decoder_err_flag</spirit:name>
                     <spirit:description>Set high to enable decoder_err_flag</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_pix_0_underflow</spirit:name>
                     <spirit:description>Set high to enable fifo_pix_0_underflow</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_pix_0_overflow</spirit:name>
                     <spirit:description>Set high to enable fifo_pix_0_overflow</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_sdp_underflow</spirit:name>
                     <spirit:description>Set high to enable fifo_sdp_underflow</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_sdp_overflow</spirit:name>
                     <spirit:description>Set high to enable fifo_sdp_overflow</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_sdp_tag_underflow</spirit:name>
                     <spirit:description>Set high to enable fifo_sdp_tag_underflow</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_sdp_tag_overflow</spirit:name>
                     <spirit:description>Set high to enable fifo_sdp_tag_overflow</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_cs_underflow</spirit:name>
                     <spirit:description>Set high to enable fifo_cs_underflow</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_cs_overflow</spirit:name>
                     <spirit:description>Set high to enable fifo_cs_overflow</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>video_stream_end</spirit:name>
                     <spirit:description>Set high to enable video_stream_end</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004948</address>
                        <intr.enable>irq0_dp_source_main</intr.enable>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending</spirit:name>
                  <spirit:description>Interrupt Pending register - This indicates which enabled interrupts have triggered, Write 1 to clear
</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>msa_dp_mvid_measured_update</spirit:name>
                     <spirit:description>Registered msa_dp_mvid_measured_update</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>first_idle_pattern_sent</spirit:name>
                     <spirit:description>Registered first_idle_pattern_sent</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>decoder_err_flag</spirit:name>
                     <spirit:description>Registered decoder_err_flag</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_pix_0_underflow</spirit:name>
                     <spirit:description>Registered fifo_pix_0_underflow</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_pix_0_overflow</spirit:name>
                     <spirit:description>Registered fifo_pix_0_overflow</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_sdp_underflow</spirit:name>
                     <spirit:description>Registered fifo_sdp_underflow</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_sdp_overflow</spirit:name>
                     <spirit:description>Registered fifo_sdp_overflow</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_sdp_tag_underflow</spirit:name>
                     <spirit:description>Registered fifo_sdp_tag_underflow</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_sdp_tag_overflow</spirit:name>
                     <spirit:description>Registered fifo_sdp_tag_overflow</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_cs_underflow</spirit:name>
                     <spirit:description>Registered fifo_cs_underflow</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_cs_overflow</spirit:name>
                     <spirit:description>Registered fifo_cs_overflow</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>video_stream_end</spirit:name>
                     <spirit:description>Registered interrupt0</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x8000494C</address>
                        <intr.status>irq0_dp_source_main</intr.status>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending_irq</spirit:name>
                  <spirit:description>Interrupt Pending register - This indicates which enabled interrupts have triggered, Write 1 to clear
</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>msa_dp_mvid_measured_update</spirit:name>
                     <spirit:description>Registered msa_dp_mvid_measured_update</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>first_idle_pattern_sent</spirit:name>
                     <spirit:description>Registered first_idle_pattern_sent</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>decoder_err_flag</spirit:name>
                     <spirit:description>Registered decoder_err_flag</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_pix_0_underflow</spirit:name>
                     <spirit:description>Registered fifo_pix_0_underflow</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_pix_0_overflow</spirit:name>
                     <spirit:description>Registered fifo_pix_0_overflow</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_sdp_underflow</spirit:name>
                     <spirit:description>Registered fifo_sdp_underflow</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_sdp_overflow</spirit:name>
                     <spirit:description>Registered fifo_sdp_overflow</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_sdp_tag_underflow</spirit:name>
                     <spirit:description>Registered fifo_sdp_tag_underflow</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_sdp_tag_overflow</spirit:name>
                     <spirit:description>Registered fifo_sdp_tag_overflow</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_cs_underflow</spirit:name>
                     <spirit:description>Registered fifo_cs_underflow</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_cs_overflow</spirit:name>
                     <spirit:description>Registered fifo_cs_overflow</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>video_stream_end</spirit:name>
                     <spirit:description>Registered interrupt0</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004950</address>
                        <intr.pending>irq0_dp_source_main</intr.pending>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>raw</spirit:name>
                  <spirit:description>This register contains the registered state of interrupt signals</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>msa_dp_mvid_measured_update</spirit:name>
                     <spirit:description>Current status of msa_dp_mvid_measured_update</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>first_idle_pattern_sent</spirit:name>
                     <spirit:description>Current status of first_idle_pattern_sent</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>decoder_err_flag</spirit:name>
                     <spirit:description>Current status of decoder_err_flag</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_pix_0_underflow</spirit:name>
                     <spirit:description>Current status of fifo_pix_0_underflow</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_pix_0_overflow</spirit:name>
                     <spirit:description>Current status of fifo_pix_0_overflow</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_sdp_underflow</spirit:name>
                     <spirit:description>Current status of fifo_sdp_underflow</spirit:description>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_sdp_overflow</spirit:name>
                     <spirit:description>Current status of fifo_sdp_overflow</spirit:description>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_sdp_tag_underflow</spirit:name>
                     <spirit:description>Current status of fifo_sdp_tag_underflow</spirit:description>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_sdp_tag_overflow</spirit:name>
                     <spirit:description>Current status of fifo_sdp_overflow</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_cs_underflow</spirit:name>
                     <spirit:description>Current status of fifo_cs_underflow</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>fifo_cs_overflow</spirit:name>
                     <spirit:description>Current status of fifo_cs_overflow</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>video_stream_end</spirit:name>
                     <spirit:description>Current status of interrupt0</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004954</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004948</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : irq  --> 
         <spirit:vendorExtensions>
               <ids_properties>
                  <module_name>dp_source_regs</module_name>
                  <uvm.package>dp_source_regs_pkg</uvm.package>
                  <reset_type>async</reset_type>
                  <cheader.mask_endianess>little</cheader.mask_endianess>
                  <explicit_name>true</explicit_name>
                  <header.struct_guard>__ASSEMBLER__</header.struct_guard>
                  <vertical_reuse>true</vertical_reuse>
                  <address>0x80004800</address>
               </ids_properties>
            </spirit:vendorExtensions>
         </spirit:addressBlock>     
         <spirit:addressBlock>     
            <spirit:name>dp_source_tico</spirit:name>
            <spirit:description>TICO Decoder Registers
</spirit:description>  <!-- //
                        block : dp_source_tico  --> 
            <spirit:baseAddress>0x80004A00</spirit:baseAddress>               
            <spirit:range>0x100</spirit:range>               
            <spirit:width>32</spirit:width>            
            <spirit:register>
               <spirit:name>tico_d_config</spirit:name>
               <spirit:addressOffset>0x10</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>tico_d_config</spirit:name>
                  <spirit:description>This register sets general core configuration parameters.
bit 0: AUTO-RESET
Set to '1' to force a user_rst and core_rst after
the last output data, on each frame. This feature
is transparent and automatic, and does not
change the control nor its configuration. It resets
the core between frames to prevent rare cases
in which the core remains in a bad state after
processing a frame whose codestream was
corrupted. See also the WaitLastCS bit below for
further details.
Set to '0' (default) to disable this feature.
bit 1: WaitLastCS
Set to '1' to wait for both the last codestream
input data and the last video output data before
auto-resetting the core, in auto-reset mode or
when an error occurred. This mode can be
selected when the input codestream is reliable
or is at least guaranteed to contain a 'last data'
flag. This mode must be selected when vid_
fixed_latency_flag is not monitored and the last
codestream word could arrive after the last video
output word.
Set to '0' (default) to wait for the last output video
data only, before auto-resetting the core. This
mode must be chosen when the input
codestream may have missing or corrupted
data, especially if the last codestream word may
be missing.
CONFIDENTIAL and</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>2</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004A10</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>tico_d_width</spirit:name>
               <spirit:addressOffset>0x14</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>tico_d_width</spirit:name>
                  <spirit:description>Image width, in pixels.
Must be a multiple of 2.
Up to 2048 for HD core flavor, 4096 for 4K core flavor, 8192 for 8K core flavor, and 10240 for 10K core flavor.</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>16</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0000000000000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004A14</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>tico_d_height</spirit:name>
               <spirit:addressOffset>0x1C</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>tico_d_height</spirit:name>
                  <spirit:description>Image height, in pixels.
Must be a multiple of 2, and greater than or equal to 2 in profile 1, 8 in profile 2.</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>16</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0000000000000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004A1C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>tico_d_comp</spirit:name>
               <spirit:addressOffset>0x24</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>tico_d_comp</spirit:name>
                  <spirit:description>Number of color components. Fixed to 3.</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>2</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004A24</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>tico_d_mode</spirit:name>
               <spirit:addressOffset>0x2C</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>tico_d_mode</spirit:name>
                  <spirit:description>bit 1-0: (R) sub-sampling mode (extracted
from picture header)
00b = 4:4:4
01b = 4:2:2
10b = 4:2:0
bit 2: (R/W) downscale
set to '1' to downscale output resolution
by a factor 2.
set to '0' for standard resolution. (default)</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>2</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004A2C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>tico_d_hlvls</spirit:name>
               <spirit:addressOffset>0x34</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>tico_d_hlvls</spirit:name>
                  <spirit:description>Number of horizontal decompositions in the horizontal wavelet transform. Fixed to 5.</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>3</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004A34</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>tico_d_vld</spirit:name>
               <spirit:addressOffset>0x38</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>tico_d_vld</spirit:name>
                  <spirit:description>Contains several mode configuration fields:
bit 1-0: (R) sub-sampling mode (extracted
from picture header), 00b = 4:4:4, 01b = 4:2:2,
10b = 4:2:0
bit 2: (R/W) downscale
set to '1' to downscale output resolution
by a factor 2.
set to '0' for standard resolution. (default)</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>write-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004A38</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>tico_d_nbr</spirit:name>
               <spirit:addressOffset>0x3C</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>tico_d_nbr</spirit:name>
                  <spirit:description>Number of images to play when the core is in command mode.</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>16</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0000000000000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004A3C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>tico_d_bgt</spirit:name>
               <spirit:addressOffset>0x44</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>tico_d_bgt</spirit:name>
                  <spirit:description>Budget in bytes for a single picture.
The budget is allocated to the picture header and the compressed data.
Note: To compute this value according to a bit per pixel rate:
budget = bpp x width x height / 8</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>32</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000000000000000000000000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004A44</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>tico_d_vid_depth</spirit:name>
               <spirit:addressOffset>0x48</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>tico_d_vid_depth</spirit:name>
                  <spirit:description>Bit depth of the video content, mapped on the MSBs of the port interface.
The valid bit depths are 8, 10 and 12 bits per component

4'b1000: 8 bits
4'b1010: 10 bits
4'b1100: 12 bits</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>4</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004A48</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>tico_d_play_mode</spirit:name>
               <spirit:addressOffset>0x4C</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>tico_d_play_mode</spirit:name>
                  <spirit:description>It allows to choose between two running modes:
- set to '1' to run in play mode, in which the core processes frames continuously.
- set to '0' to run in command mode, in which the core processes n frames, n defined by TICO_D_NBR.</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>write-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004A4C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>tico_d_profile</spirit:name>
               <spirit:addressOffset>0x58</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>tico_d_profile</spirit:name>
                  <spirit:description>Codestream profile:
 1: Profile 1
 2: Profile 2
The profile must be compliant with the core performance and configuration.</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>2</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004A58</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>tico_d_line_duration</spirit:name>
               <spirit:addressOffset>0x80</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>tico_d_line_duration</spirit:name>
                  <spirit:description>Number of clock cycles per video line (horizontal blanking included). This register is used to generate the fixed
latency flag signal.</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>16</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0000000000000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004A80</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>tico_d_img_size</spirit:name>
               <spirit:addressOffset>0x84</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>tico_d_line_duration</spirit:name>
                  <spirit:description>Image size configuration of the Video Out Synchronizer.
When this register is null, the Video Out Synchronizer
takes the image size from the codestream header.
Otherwise, it takes it from this register and disregards
the codestream header, which is safer in an
environment where codestream corruption is possible.
bits 31-16: image width
bits 15-1: image height / 2 (number of line
pairs) 
bit 0: subsampling mode, 0 = 4:4:4, 1 = 4:2:2 /
4:2:0
Note: this register is only used for the Video Out
Synchronizer, not for the TICO decoder which must take
the image size from the picture header.</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>32</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000000000000000000000000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004A84</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>         
            <spirit:vendorExtensions>
               <ids_properties>
                  <module_name>tico_decoder_regs</module_name>
                  <uvm.package>tico_decoder_regs_pkg</uvm.package>
                  <reset_type>async</reset_type>
                  <cheader.mask_endianess>little</cheader.mask_endianess>
                  <header.struct_guard>__ASSEMBLER__</header.struct_guard>
                  <explicit_name>true</explicit_name>
                  <vertical_reuse>true</vertical_reuse>
                  <address>0x80004A00</address>
               </ids_properties>
            </spirit:vendorExtensions>
         </spirit:addressBlock>     
         <spirit:addressBlock>     
            <spirit:name>dp_source_aux_hpd</spirit:name>
            <spirit:description>DP aux hpd
</spirit:description>  <!-- //
                        block : dp_source_aux_hpd  --> 
            <spirit:baseAddress>0x80004B00</spirit:baseAddress>               
            <spirit:range>0x100</spirit:range>               
            <spirit:width>32</spirit:width>            
            <spirit:register>
               <spirit:name>version</spirit:name>
               <spirit:description>Version</spirit:description>
               <spirit:addressOffset>0x0</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00040400</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>major</spirit:name>
                  <spirit:description>Major version</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000100</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>minor</spirit:name>
                  <spirit:description>Minor version</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000100</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>patch</spirit:name>
                  <spirit:description>Patch version</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004B00</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>aux_status</spirit:name>
               <spirit:description>Error bits for source/sink and misc status bits</spirit:description>
               <spirit:addressOffset>0x4</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0xA0000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>aux_sense_p_in_debounce</spirit:name>
                  <spirit:description>Aux + line status after de-bouncing 
1: DP source device is not connected
0: DP source device is connected</spirit:description>
                  <spirit:bitOffset>31</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>1</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>aux_sense_n_in_debounce</spirit:name>
                  <spirit:description>Aux - line status after de-bouncing

1: DP source device provides power on DP_PWR pin
0: DP source device does not provide power for sink</spirit:description>
                  <spirit:bitOffset>30</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>aux_sense_p_in</spirit:name>
                  <spirit:description>Aux + line status 
1: DP source device is not connected
0: DP source device is connected</spirit:description>
                  <spirit:bitOffset>29</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>1</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>aux_sense_n_in</spirit:name>
                  <spirit:description>Aux - line status 
1: DP source device provides power on DP_PWR pin
0: DP source device does not provide power for sink</spirit:description>
                  <spirit:bitOffset>28</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>sent_defer_cnt</spirit:name>
                  <spirit:description>Number of sent defers</spirit:description>
                  <spirit:bitOffset>24</spirit:bitOffset>
                  <spirit:bitWidth>4</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>response_timeout_cnt</spirit:name>
                  <spirit:description>Response timer value</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>17</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000000000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004B04</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>aux_ctrl1</spirit:name>
               <spirit:description>Aux control 1</spirit:description>
               <spirit:addressOffset>0x8</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0xC8009600</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>reply_timer</spirit:name>
                  <spirit:description>400us response timer setting in 0.0625 us step</spirit:description>
                  <spirit:bitOffset>19</spirit:bitOffset>
                  <spirit:bitWidth>13</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>1100100000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>response_timer</spirit:name>
                  <spirit:description>300us response timer setting in 0.0625 us step</spirit:description>
                  <spirit:bitOffset>3</spirit:bitOffset>
                  <spirit:bitWidth>13</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>1001011000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004B08</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>aux_ctrl2</spirit:name>
               <spirit:description>Aux control 2</spirit:description>
               <spirit:addressOffset>0xC</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x001F0000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>pre_charge_length</spirit:name>
                  <spirit:description>Number of Zeroes in pre-charge period (register value + 1)</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>5</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>11111</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004B0C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>aux_ctrl3</spirit:name>
               <spirit:description>Aux control 3</spirit:description>
               <spirit:addressOffset>0x10</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x0000004B</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>dp_aux_hpd_clk_freq</spirit:name>
                  <spirit:description>DP Aux and Hpd clock frequency in Mhz</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>01001011</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004B10</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>aux_rx</spirit:name>
               <spirit:description>Aux receiver data and flag register</spirit:description>
               <spirit:addressOffset>0x14</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>rx_flag</spirit:name>
                  <spirit:description>High in EOP cycle</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>rx_data</spirit:name>
                  <spirit:description>aux received data</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                     <ids_properties>
                        <rtl.hw_rp>1</rtl.hw_rp>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004B14</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>aux_tx</spirit:name>
               <spirit:description>Aux transmitter data and flag register</spirit:description>
               <spirit:addressOffset>0x18</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>go_bit</spirit:name>
                  <spirit:description>Set high to assert aux go_bit (source or sink)</spirit:description>
                  <spirit:bitOffset>9</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                     <ids_properties>
                        <rtl.hw_clear>1</rtl.hw_clear>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>tx_flag</spirit:name>
                  <spirit:description>High in EOP cycle</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>write-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>tx_data</spirit:name>
                  <spirit:description>aux transmit data</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>write-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                     <ids_properties>
                        <rtl.hw_wp>1</rtl.hw_wp>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004B18</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>hpd_status</spirit:name>
               <spirit:description>Error bits for source/sink and misc status bits</spirit:description>
               <spirit:addressOffset>0x1C</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>hpd_line_out</spirit:name>
                  <spirit:description>HPD line out status</spirit:description>
                  <spirit:bitOffset>2</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>hpd_line_in_debounce</spirit:name>
                  <spirit:description>HPD line in after de-bouncing status</spirit:description>
                  <spirit:bitOffset>1</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>hpd_line_in</spirit:name>
                  <spirit:description>HPD line in status</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004B1C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>hpd_ctrl</spirit:name>
               <spirit:description>HPD generator control bits</spirit:description>
               <spirit:addressOffset>0x20</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>hpd_low</spirit:name>
                  <spirit:description>Set high to generate LOW on HPD</spirit:description>
                  <spirit:bitOffset>3</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                     <ids_properties>
                        <rtl.hw_clear>1</rtl.hw_clear>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>hpd_high</spirit:name>
                  <spirit:description>Set high to generate HIGH on HPD</spirit:description>
                  <spirit:bitOffset>2</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                     <ids_properties>
                        <rtl.hw_clear>1</rtl.hw_clear>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>hpd_replug</spirit:name>
                  <spirit:description>Set high to generate a long pulse on HPD</spirit:description>
                  <spirit:bitOffset>1</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                     <ids_properties>
                        <rtl.hw_clear>1</rtl.hw_clear>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>hpd_irq</spirit:name>
                  <spirit:description>Set high to generate IRQ pulse on HPD</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                     <ids_properties>
                        <rtl.hw_clear>1</rtl.hw_clear>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004B20</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>hpd_timer1</spirit:name>
               <spirit:description>Aux control</spirit:description>
               <spirit:addressOffset>0x24</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x0000200C</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>hpd_irq_to_irq_min_gap</spirit:name>
                  <spirit:description>2048 us hpd_irq to hpd_irq minimum gap setting in 64 us step step (spec indicates minimum of 2ms)</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>6</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>100000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>hpd_irq_pulse_width</spirit:name>
                  <spirit:description>768 us hpd_irq pulse setting in 64 us step (spec indicates 0.5ms to 1ms)</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>4</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>1100</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004B24</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>hpd_timer2</spirit:name>
               <spirit:description>Aux control</spirit:description>
               <spirit:addressOffset>0x28</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x0000009C</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>hpd_replug_pulse_width</spirit:name>
                  <spirit:description>9.984us hpd_replug pulse setting in 64 us step (spec indicates 2ms to 100ms)</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>10011100</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004B28</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>hpd_timer3</spirit:name>
               <spirit:description>Aux control</spirit:description>
               <spirit:addressOffset>0x2C</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x001F461A</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>hpd_irq_rising_detect</spirit:name>
                  <spirit:description>Rising pulse 2ms detection of hpd_irq (in 64us steps)</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>6</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>011111</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>hpd_irq_falling_detect</spirit:name>
                  <spirit:description>Falling pulse 0.25ms detection of hpd_irq (in 64us steps)</spirit:description>
                  <spirit:bitOffset>12</spirit:bitOffset>
                  <spirit:bitWidth>4</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0100</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>hpd_aux_debounce_period</spirit:name>
                  <spirit:description>De-bounce period of 100ms for hpd and aux sense signals (in 64us steps)</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>11</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>11000011010</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004B2C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>hpd_rise_det</spirit:name>
               <spirit:description>HPD line falling edge counter logic</spirit:description>
               <spirit:addressOffset>0x30</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>cnt</spirit:name>
                  <spirit:description>Count value. It saturates at 8'd255.</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>rst</spirit:name>
                  <spirit:description>Write 1 and then 0 to reset the counter.</spirit:description>
                  <spirit:bitOffset>4</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>ctrl</spirit:name>
                  <spirit:description>1'b1: Start counter
1'b0: Stop counter</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004B30</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>hpd_fall_det</spirit:name>
               <spirit:description>HPD line falling edge counter logic</spirit:description>
               <spirit:addressOffset>0x34</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>cnt</spirit:name>
                  <spirit:description>Count value. It saturates at 8'd255.</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>rst</spirit:name>
                  <spirit:description>Write 1 and then 0 to reset the counter.</spirit:description>
                  <spirit:bitOffset>4</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>ctrl</spirit:name>
                  <spirit:description>1'b1: Start counter
1'b0: Stop counter</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004B34</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>dp_source_connect_det</spirit:name>
               <spirit:description>DP source connect detect counter logic</spirit:description>
               <spirit:addressOffset>0x38</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>cnt</spirit:name>
                  <spirit:description>Count value. It saturates at 8'd255.</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>rst</spirit:name>
                  <spirit:description>Write 1 and then 0 to reset the counter.</spirit:description>
                  <spirit:bitOffset>4</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>ctrl</spirit:name>
                  <spirit:description>1'b1: Start counter
1'b0: Stop counter</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004B38</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>dp_source_disconnect_det</spirit:name>
               <spirit:description>DP source disconnect detect counter logic</spirit:description>
               <spirit:addressOffset>0x3C</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>cnt</spirit:name>
                  <spirit:description>Count value. It saturates at 8'd255.</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>rst</spirit:name>
                  <spirit:description>Write 1 and then 0 to reset the counter.</spirit:description>
                  <spirit:bitOffset>4</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>ctrl</spirit:name>
                  <spirit:description>1'b1: Start counter
1'b0: Stop counter</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004B3C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>
  <!-- reg group
                    :irq  --> 
          <spirit:registerFile>
               <spirit:name>irq</spirit:name>
               <spirit:description>aux_hpd Interrupt register group</spirit:description>
               <spirit:addressOffset>0x40</spirit:addressOffset>
               <spirit:range>0x10</spirit:range>            
               <spirit:register>
                  <spirit:name>enable</spirit:name>
                  <spirit:description>Interrupt Enable register - Write 1 to enable, 0 to mask an interrupt
</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>dp_source_connect_det</spirit:name>
                     <spirit:description>Set high to enable dp_source_connect_det interrupt</spirit:description>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_source_disconnect_det</spirit:name>
                     <spirit:description>Set high to enable dp_source_disconnect_det interrupt</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_rise_det</spirit:name>
                     <spirit:description>Set high to enable hpd_rise_det interrupt</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_fall_det</spirit:name>
                     <spirit:description>Set high to enable hpd_fall_det interrupt</spirit:description>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_source_powered</spirit:name>
                     <spirit:description>Set high to enable dp_source_powered interrupt</spirit:description>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_source_detected</spirit:name>
                     <spirit:description>Set high to enable dp_source_detected interrupt</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_disconnect</spirit:name>
                     <spirit:description>Set high to enable hpd_disconnect interrupt</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_connect</spirit:name>
                     <spirit:description>Set high to enable hpd_connect interrupt</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_irq</spirit:name>
                     <spirit:description>Set high to enable hpd_irq interrupt</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_replug</spirit:name>
                     <spirit:description>Set high to enable hpd_replug interrupt</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_fifo_overflow</spirit:name>
                     <spirit:description>Set high to enable rx_fifo_overflow</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>reply_timeout</spirit:name>
                     <spirit:description>Set high to enable reply timeout interrupt</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>defer_sent</spirit:name>
                     <spirit:description>Set high to enable defer_sent interrupt</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>go_bit_clear</spirit:name>
                     <spirit:description>Set high to enable go_bit_clear interrupt</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_fifo_pkt_received</spirit:name>
                     <spirit:description>Set high to enable rx_fifo_pkt_received interrupt</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004B40</address>
                        <intr.enable>irq0_dp_source_aux_hpd</intr.enable>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending</spirit:name>
                  <spirit:description>Interrupt Pending register - This indicates which enabled interrupts have triggered, Write 1 to clear
</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>dp_source_connect_det</spirit:name>
                     <spirit:description>Registered dp_source_connect_det</spirit:description>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_source_disconnect_det</spirit:name>
                     <spirit:description>Registered dp_source_disconnect_det</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_rise_det</spirit:name>
                     <spirit:description>Registered hpd_rise_det</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_fall_det</spirit:name>
                     <spirit:description>Registered hpd_fall_det</spirit:description>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_source_powered</spirit:name>
                     <spirit:description>Registered dp_source_powered</spirit:description>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_source_detected</spirit:name>
                     <spirit:description>Registered dp_source_detected</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_disconnect</spirit:name>
                     <spirit:description>Registered hpd_disconnect</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_connect</spirit:name>
                     <spirit:description>Registered hpd_connect</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_irq</spirit:name>
                     <spirit:description>Registered hpd_irq</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_replug</spirit:name>
                     <spirit:description>Registered hpd_replug</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_fifo_overflow</spirit:name>
                     <spirit:description>Registered rx_fifo_overflow</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>reply_timeout</spirit:name>
                     <spirit:description>Registered reply timeout</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>defer_sent</spirit:name>
                     <spirit:description>Registered defer_sent</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>go_bit_clear</spirit:name>
                     <spirit:description>Registered go_bit_clear</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_fifo_pkt_received</spirit:name>
                     <spirit:description>Registered rx_fifo_pkt_received</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004B44</address>
                        <intr.status>irq0_dp_source_aux_hpd</intr.status>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending_irq</spirit:name>
                  <spirit:description>Interrupt Pending register - This indicates which enabled interrupts have triggered, Write 1 to clear
</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>dp_source_connect_det</spirit:name>
                     <spirit:description>Registered dp_source_connect_det</spirit:description>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_source_disconnect_det</spirit:name>
                     <spirit:description>Registered dp_source_disconnect_det</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_rise_det</spirit:name>
                     <spirit:description>Registered hpd_rise_det</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_fall_det</spirit:name>
                     <spirit:description>Registered hpd_fall_det</spirit:description>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_source_powered</spirit:name>
                     <spirit:description>Registered dp_source_powered</spirit:description>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_source_detected</spirit:name>
                     <spirit:description>Registered dp_source_detected</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_disconnect</spirit:name>
                     <spirit:description>Registered hpd_disconnect</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_connect</spirit:name>
                     <spirit:description>Registered hpd_connect</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_irq</spirit:name>
                     <spirit:description>Registered hpd_irq</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_replug</spirit:name>
                     <spirit:description>Registered hpd_replug</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_fifo_overflow</spirit:name>
                     <spirit:description>Registered rx_fifo_overflow</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>reply_timeout</spirit:name>
                     <spirit:description>Registered reply timeout</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>defer_sent</spirit:name>
                     <spirit:description>Registered defer_sent</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>go_bit_clear</spirit:name>
                     <spirit:description>Registered go_bit_clear</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_fifo_pkt_received</spirit:name>
                     <spirit:description>Registered rx_fifo_pkt_received</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004B48</address>
                        <intr.pending>irq0_dp_source_aux_hpd</intr.pending>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>raw</spirit:name>
                  <spirit:description>This register contains the registered state of interrupt signals</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>dp_source_connect_det</spirit:name>
                     <spirit:description>Current status of dp_source_connect_det</spirit:description>
                     <spirit:bitOffset>17</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_source_disconnect_det</spirit:name>
                     <spirit:description>Current status of dp_source_disconnect_det</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_rise_det</spirit:name>
                     <spirit:description>Current status of hpd_rise_det</spirit:description>
                     <spirit:bitOffset>15</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_fall_det</spirit:name>
                     <spirit:description>Current status of hpd_fall_det</spirit:description>
                     <spirit:bitOffset>14</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_source_powered</spirit:name>
                     <spirit:description>Current status of dp_source_powered</spirit:description>
                     <spirit:bitOffset>13</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dp_source_detected</spirit:name>
                     <spirit:description>Current status of dp_source_detected</spirit:description>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_disconnect</spirit:name>
                     <spirit:description>Current status of hpd_disconnect</spirit:description>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_connect</spirit:name>
                     <spirit:description>Current status of hpd_connect</spirit:description>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_irq</spirit:name>
                     <spirit:description>Current status of hpd_irq</spirit:description>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>hpd_replug</spirit:name>
                     <spirit:description>Current status of hpd_replug</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_fifo_overflow</spirit:name>
                     <spirit:description>Current status of rx_fifo_overflow</spirit:description>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>reply_timeout</spirit:name>
                     <spirit:description>Current status of reply timeout</spirit:description>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>defer_sent</spirit:name>
                     <spirit:description>Current status of defer_sent</spirit:description>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>go_bit_clear</spirit:name>
                     <spirit:description>Current status of go_bit_clear</spirit:description>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rx_fifo_pkt_received</spirit:name>
                     <spirit:description>Current status of rx_fifo_pkt_received</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004B4C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004B40</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : irq  --> 
         <spirit:vendorExtensions>
               <ids_properties>
                  <module_name>dp_aux_hpd_regs</module_name>
                  <uvm.package>dp_aux_hpd_regs_pkg</uvm.package>
                  <reset_type>async</reset_type>
                  <cheader.mask_endianess>little</cheader.mask_endianess>
                  <explicit_name>true</explicit_name>
                  <header.struct_guard>__ASSEMBLER__</header.struct_guard>
                  <vertical_reuse>true</vertical_reuse>
                  <address>0x80004B00</address>
               </ids_properties>
            </spirit:vendorExtensions>
         </spirit:addressBlock>     
         <spirit:addressBlock>     
            <spirit:name>xusb3</spirit:name>
            <spirit:description>XUSB3 Registers
</spirit:description>  <!-- //
                        block : xusb3  --> 
            <spirit:baseAddress>0x80004C00</spirit:baseAddress>               
            <spirit:range>0x200</spirit:range>               
            <spirit:width>32</spirit:width>            
            <spirit:register>
               <spirit:name>version</spirit:name>
               <spirit:description>2.0.0: Added new clock for ITP Manager Support.
3.0.0: Added new reset domain for UPP and separated from XUSB3
3.1.0: Changed the Interrupt Pending to avoid blocking the register update when enable is 0
3.2.0: Added pending_irq register
3.3.0: Bug fix and register name change
3.4.0: Bug fix in RX Partner Manager
3.5.0: Add sensitivity to DPH and DPP in RX Partner, and number of other enhancements
3.5.1: Removed back pressure to MCA that resulted timing loop, and removed mark_debug to improve timing
3.5.2: put back the back pressure to MCA again but enabled write pipeline for PFIFO to address timing loop
4.0.0: Add elastic buffer registers and bug fix for purging data</spirit:description>
               <spirit:addressOffset>0x0</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00040000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>major</spirit:name>
                  <spirit:description>Major version</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000100</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>minor</spirit:name>
                  <spirit:description>Minor version</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>patch</spirit:name>
                  <spirit:description>Patch version</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004C00</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>configuration</spirit:name>
               <spirit:addressOffset>0x4</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>true</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x202FFFF0</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>rx_buff_near_full_limit</spirit:name>
                  <spirit:description>The number of cycles limit of the RX Partner FIFO before its maximum value over which the DPP portion of the in data is dropped and only DPH are saved to guard against any lost DPH.</spirit:description>
                  <spirit:bitOffset>22</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>10000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>upp_bypass</spirit:name>
                  <spirit:description>This register is only valid when upp_is_present=1. 
When set to 0, it enables the USB Protocol Partner (UPP) logic in the XUSB3 and moves the traffic through the UPP. When set to 1, it bypasses the UPP and the traffic is from USB Link Partner (ULP) to/from core.</spirit:description>
                  <spirit:bitOffset>21</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>1</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>upp_is_present</spirit:name>
                  <spirit:description>This register shows if the UPP logic has been instantiated in the logic.</spirit:description>
                  <spirit:bitOffset>20</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>split_dp_wait_time</spirit:name>
                  <spirit:description>Indicates the number of Core Cycles that the RX Partner Manager waits for the DPP portion of a split DP packet to arrive. After this wait, if the DPP does not arrive, the logic will send the DPH portion to the Host and will drop the DPP if it comes later. A value of 0 disables this wait and requires back-2-back DPH and DPP.
Note the impact of this value on the USB end-to-end latency on one extreme and on the integrity of the USB DP packet delivery on the other.</spirit:description>
                  <spirit:bitOffset>4</spirit:bitOffset>
                  <spirit:bitWidth>16</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>1111111111111111</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>split_dp_mode</spirit:name>
                  <spirit:description>When 1, it instructs to split the DP USB packets into DPH and DPP packets when sent over the system link as two independent PTP packets. These DPH and DPP PTP packets will join on the other side into the same DP USB in normal operation (not in retry operation)</spirit:description>
                  <spirit:bitOffset>3</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>allow_rx_buff_fill</spirit:name>
                  <spirit:description>When 1, it allows the RX Link Partner buffer to accept the partner's packet even if the Link Layer (ULP) is not ready to process these packets yet. The ULP is only ready to process these packets when it is in U0 and has finished the LMP.</spirit:description>
                  <spirit:bitOffset>2</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>drop_itp_pkts</spirit:name>
                  <spirit:description>When 1 it instructs the LEX to drop the ITP packets and not send them to REX.</spirit:description>
                  <spirit:bitOffset>1</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>upstream_port</spirit:name>
                  <spirit:description>When 1, it indicates the XUSB3 works as an Upstream Port (used in LEX). When 0, it is a Downstream port used in REX.</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004C04</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>control</spirit:name>
               <spirit:addressOffset>0x8</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00000000</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>remove_crdts</spirit:name>
                  <spirit:description>When 1, it forces the Link Layer to not issue credit to its USB link partner. This will effectively stop receiving any data or header packets from the link partner. This bit is mainly for debugging and software should not use it under normal system usage.</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004C08</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>
  <!-- reg group
                    :rx_partner_fifo  --> 
          <spirit:registerFile>
               <spirit:name>rx_partner_fifo</spirit:name>
               <spirit:addressOffset>0xC</spirit:addressOffset>
               <spirit:range>0x50</spirit:range>            
               <spirit:register>
                  <spirit:name>version</spirit:name>
                  <spirit:description>Version 1.1.0: Added Icron Attributes for stats script generation</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00010100</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>major</spirit:name>
                     <spirit:description>Major version</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000001</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>minor</spirit:name>
                     <spirit:description>Minor version</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000001</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>patch</spirit:name>
                     <spirit:description>Patch version</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004C0C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
  <!-- reg group
                    :write_engine  --> 
          <spirit:registerFile>
                  <spirit:name>write_engine</spirit:name>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:range>0x38</spirit:range>
  <!-- reg group
                    :config0  --> 
          <spirit:registerFile>
                     <spirit:name>config0</spirit:name>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:range>0xC</spirit:range>            
                     <spirit:register>
                        <spirit:name>clear</spirit:name>
                        <spirit:description>Synchronous clear for the write clock domain</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>wclr</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80004C10</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>mode</spirit:name>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000005</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>drp_on_sop</spirit:name>
                           <spirit:description>When set, drops the current packet without writing it to the buffer. See Wiki</spirit:description>
                           <spirit:bitOffset>3</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>drp_on_pkt_err</spirit:name>
                           <spirit:description>When set, removes the packet from the buffer without presenting it to the output interface upon the ERR bit being set before the notification point. See Wiki</spirit:description>
                           <spirit:bitOffset>2</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>1</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pkt_strm</spirit:name>
                           <spirit:description>Selects packet based or streaming based behavior. See Wiki</spirit:description>
                           <spirit:bitOffset>1</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>flw_ctrl_en</spirit:name>
                           <spirit:description>Enables the flow control. See Wiki</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>1</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80004C14</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>notify_limit</spirit:name>
                        <spirit:addressOffset>0x8</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>ntfy_lmt</spirit:name>
                           <spirit:description>Sets the number of words required to be written into the packet FIFO before a notification will be generated. See wiki</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>32</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000000000000000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80004C18</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004C10</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : config0  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                     <spirit:name>stats0</spirit:name>
                     <spirit:description>All the Statistic Registers and their configuration for the Write Engine</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:range>0x2C</spirit:range>            
                     <spirit:register>
                        <spirit:name>rd2clr_config</spirit:name>
                        <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:bitOffset>9</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>drp_pkt_wr</spirit:name>
                           <spirit:bitOffset>8</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>drp_pkt_rd</spirit:name>
                           <spirit:bitOffset>7</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>wflush_act</spirit:name>
                           <spirit:bitOffset>6</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pkt_sop_err</spirit:name>
                           <spirit:bitOffset>5</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pkt_err</spirit:name>
                           <spirit:bitOffset>4</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>fifo_full_err</spirit:name>
                           <spirit:bitOffset>3</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pkt_max_byte_cnt_err</spirit:name>
                           <spirit:bitOffset>2</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pfifo_dcount</spirit:name>
                           <spirit:bitOffset>1</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>nfifo_dcount</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004C1C</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>nfifo_dcount</spirit:name>
                        <spirit:description>Current level for the notification FIFO in the PFIFO</spirit:description>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>nfifo_dcount</spirit:name>
                           <spirit:description>_icron_water_marker_
_icron_no_counter_</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004C20</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pfifo_dcount</spirit:name>
                        <spirit:description>Current level for the packet FIFO in the PFIFO</spirit:description>
                        <spirit:addressOffset>0x8</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>pfifo_dcount</spirit:name>
                           <spirit:description>_icron_water_marker_
_icron_no_counter_</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004C24</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pkt_max_byte_cnt_err</spirit:name>
                        <spirit:description>The count for capped packets in PFIFO write engine, as the result of reaching maximum size in the PFIFO</spirit:description>
                        <spirit:addressOffset>0xC</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>pkt_max_byte_cnt_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004C28</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>fifo_full_err</spirit:name>
                        <spirit:description>The count for either of PFIFO or NFIFO being full</spirit:description>
                        <spirit:addressOffset>0x10</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>fifo_full_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004C2C</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pkt_err</spirit:name>
                        <spirit:description>The count of packets tagged to be dropped later in the PFIFO read engine</spirit:description>
                        <spirit:addressOffset>0x14</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>pkt_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004C30</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pkt_sop_err</spirit:name>
                        <spirit:description>The count of packets flushed in the PFIFO during the SOP phase</spirit:description>
                        <spirit:addressOffset>0x18</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>pkt_sop_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004C34</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>wflush_act</spirit:name>
                        <spirit:description>The count of capped packets in the PFIFO. Note that back-to-back packets are counted as one if they are both capped.</spirit:description>
                        <spirit:addressOffset>0x1C</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>wflush_act</spirit:name>
                           <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004C38</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>drp_pkt_rd</spirit:name>
                        <spirit:description>The count of drop packets flagged to be dropped by the read engine</spirit:description>
                        <spirit:addressOffset>0x20</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>drp_pkt_rd</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004C3C</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>drp_pkt_wr</spirit:name>
                        <spirit:description>The count of drop packets by the write engine</spirit:description>
                        <spirit:addressOffset>0x24</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>drp_pkt_wr</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004C40</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>flow_ctrl</spirit:name>
                        <spirit:description>The count of the clock cycles the DRDY is asserted low resulting in flow control</spirit:description>
                        <spirit:addressOffset>0x28</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004C44</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004C1C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 
<spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004C10</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : write_engine  --> 

  <!-- reg group
                    :read_engine  --> 
          <spirit:registerFile>
                  <spirit:name>read_engine</spirit:name>
                  <spirit:addressOffset>0x3C</spirit:addressOffset>
                  <spirit:range>0x14</spirit:range>
  <!-- reg group
                    :config0  --> 
          <spirit:registerFile>
                     <spirit:name>config0</spirit:name>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:range>0x4</spirit:range>            
                     <spirit:register>
                        <spirit:name>clear</spirit:name>
                        <spirit:description>Synchronous clear for the read clock domain</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>rclr</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80004C48</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004C48</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : config0  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                     <spirit:name>stats0</spirit:name>
                     <spirit:description>All the Statistic Registers and their configuration for the Read Engine</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:range>0x10</spirit:range>            
                     <spirit:register>
                        <spirit:name>rd2clr_config</spirit:name>
                        <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:bitOffset>2</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>drp_pkt</spirit:name>
                           <spirit:bitOffset>1</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>rflush_act</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004C4C</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>rflush_act</spirit:name>
                        <spirit:description>The counts of number of packets flushed from the PFIFO.</spirit:description>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>rflush_act</spirit:name>
                           <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004C50</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>drp_pkt</spirit:name>
                        <spirit:description>The counts of drop packet in the PFIFO read engine</spirit:description>
                        <spirit:addressOffset>0x8</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>drp_pkt</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004C54</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>flow_ctrl</spirit:name>
                        <spirit:description>The count of the clock cycles the DRDY is asserted low resulting in flow control</spirit:description>
                        <spirit:addressOffset>0xC</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004C58</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004C4C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 
<spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004C48</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : read_engine  --> 
<spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004C0C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : rx_partner_fifo  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
               <spirit:name>stats0</spirit:name>
               <spirit:description>All the Statistic Registers and their configuration</spirit:description>
               <spirit:addressOffset>0x5C</spirit:addressOffset>
               <spirit:range>0x38</spirit:range>            
               <spirit:register>
                  <spirit:name>rd2clr_config</spirit:name>
                  <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>not_rdy_pkt_drp</spirit:name>
                     <spirit:bitOffset>12</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>timedout_2join_dpp</spirit:name>
                     <spirit:bitOffset>11</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>rcvd_lone_dph</spirit:name>
                     <spirit:bitOffset>10</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>drop_lone_dpp</spirit:name>
                     <spirit:bitOffset>9</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>dwn_stream_busy_drp</spirit:name>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>unknown_pkt_drp</spirit:name>
                     <spirit:bitOffset>7</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>from_link_in_eop</spirit:name>
                     <spirit:bitOffset>6</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>from_link_in_sop</spirit:name>
                     <spirit:bitOffset>5</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>to_link_out_eop</spirit:name>
                     <spirit:bitOffset>4</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>to_link_out_sop</spirit:name>
                     <spirit:bitOffset>3</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>from_phy_in_eop</spirit:name>
                     <spirit:bitOffset>2</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>from_phy_in_sop</spirit:name>
                     <spirit:bitOffset>1</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>link_partner_ptp_violated</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004C5C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>link_partner_ptp_violated</spirit:name>
                  <spirit:description>Count the number of PTP Protocol Violation in the Link Partner Manager</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>link_partner_ptp_violated</spirit:name>
                     <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004C60</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>from_phy_in_sop</spirit:name>
                  <spirit:description>Count the number of PTP sop from USB PHY</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>from_phy_in_sop</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>32</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000000000000000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004C64</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>from_phy_in_eop</spirit:name>
                  <spirit:description>Count the number of PTP eop from USB PHY</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>from_phy_in_eop</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>32</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000000000000000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004C68</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>to_link_out_sop</spirit:name>
                  <spirit:description>Count the number of PTP sop to the Eth Link path</spirit:description>
                  <spirit:addressOffset>0x10</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>to_link_out_sop</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>32</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000000000000000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004C6C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>to_link_out_eop</spirit:name>
                  <spirit:description>Count the number of PTP eop to the Eth Link path</spirit:description>
                  <spirit:addressOffset>0x14</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>to_link_out_eop</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>32</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000000000000000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004C70</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>from_link_in_sop</spirit:name>
                  <spirit:description>Count the number of PTP sop from the Eth Link path</spirit:description>
                  <spirit:addressOffset>0x18</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>from_link_in_sop</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>32</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000000000000000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004C74</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>from_link_in_eop</spirit:name>
                  <spirit:description>Count the number of PTP eop from the Eth Link path</spirit:description>
                  <spirit:addressOffset>0x1C</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>from_link_in_eop</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>32</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000000000000000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004C78</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>unknown_pkt_drp</spirit:name>
                  <spirit:description>Count of unknown packets dropped at the TX Link Partner Manager</spirit:description>
                  <spirit:addressOffset>0x20</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>unknown_pkt_drp</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004C7C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>dwn_stream_busy_drp</spirit:name>
                  <spirit:description>Count of the DPP portion of DP packet being truncated when the TX Link Partner Manager downstream (MCA) is flow controlling</spirit:description>
                  <spirit:addressOffset>0x24</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>dwn_stream_busy_drp</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004C80</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>drop_lone_dpp</spirit:name>
                  <spirit:description>Count of the lone (not preceded with DPH) DPP received at the RX Link Partner Manager that were dropped</spirit:description>
                  <spirit:addressOffset>0x28</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>drop_lone_dpp</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004C84</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>rcvd_lone_dph</spirit:name>
                  <spirit:description>Count of the lone DPH (not followed by DPP) received at the RX Link Partner Manager</spirit:description>
                  <spirit:addressOffset>0x2C</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>rcvd_lone_dph</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004C88</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>timedout_2join_dpp</spirit:name>
                  <spirit:description>Count of the number of times that a DPH was received and it was not followed by a DPP after exhausting the wait period as instructed in the Configuration Register</spirit:description>
                  <spirit:addressOffset>0x30</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>timedout_2join_dpp</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004C8C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>not_rdy_pkt_drp</spirit:name>
                  <spirit:description>Count of the number of times a PTP packet was received from the Link Partner at the RX and it was dropped as the ULP core is not ready to process yet. The ULP core is only ready to process these packets when it is in U0 and has finished the LMP.

This count only will show when allow_rx_buff_fill register in the Configuration is set to 1'b0. Otherwise, PTP packets are not dropped and are written into the buffer.</spirit:description>
                  <spirit:addressOffset>0x34</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>not_rdy_pkt_drp</spirit:name>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>16</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0000000000000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <external>true</external>
                        <address>0x80004C90</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004C5C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 

  <!-- reg group
                    :ptp_guard_2core  --> 
          <spirit:registerFile>
               <spirit:name>ptp_guard_2core</spirit:name>
               <spirit:addressOffset>0x94</spirit:addressOffset>
               <spirit:range>0x2C</spirit:range>            
               <spirit:register>
                  <spirit:name>version</spirit:name>
                  <spirit:description>3.1.0: Fixed bug in Max Cycle Error where in certain mode the cycles were included in the count
3.2.0: Changed the Interrupt Pending to avoid blocking the register update when enable is 0
3.3.0: Added pending_irq register</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00030300</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>major</spirit:name>
                     <spirit:description>Major version</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000011</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>minor</spirit:name>
                     <spirit:description>Minor version</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000011</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>patch</spirit:name>
                     <spirit:description>Patch version</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004C94</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
  <!-- reg group
                    :config0  --> 
          <spirit:registerFile>
                  <spirit:name>config0</spirit:name>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:range>0x8</spirit:range>            
                  <spirit:register>
                     <spirit:name>fix_ptp_violations</spirit:name>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000001</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>implemented</spirit:name>
                        <spirit:description>This is the synthesis parameter value used. When 1, it shows the PTP Guard fix logic has been implemented</spirit:description>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>activate</spirit:name>
                        <spirit:description>When 1, and if the fix logic is implemented, it instructs the PTP Guard to fix the PTP violations it detects (and reports). Note that there is a synthesis parameter to generate the "fix" logic or not

When 0, no attempt is done to fix (even if the logic exists) and the PTP Guard will only work as a monitor and reports the violations detected.

For full details of the operation, what violations are detected and fixed, and how the fix is done, see the wiki.</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>1</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004C98</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>max_cycles</spirit:name>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00030000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_mode</spirit:name>
                        <spirit:description>This configures the mode of counting towards max_cycles:

0x0: All PTP cycles are included in the count
0x1: PTP cycles with backpressure (drdy=1'b0) are excluded from the count
0x2: PTP cycles with wait (srdy=1'b0) are excluded from the count
0x3: PTP cycles with either backpressure or wait are excluded from the count. Hence, only "absorbed" PTP cycles are included in the count

Other mode values are reserved</spirit:description>
                        <spirit:bitOffset>16</spirit:bitOffset>
                        <spirit:bitWidth>4</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0011</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>max_cycles</spirit:name>
                        <spirit:description>Sets the maximum number of clock cycles the PTP packet can last between its sop and eop taking into account the max_cycle_mode

When set to 0, it instructs the logic not to fix this violation (when the fix logic is available). However, the monitor will still issue a violation when the cycle count reaches its maximum and rollover.</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004C9C</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004C98</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : config0  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                  <spirit:name>stats0</spirit:name>
                  <spirit:description>All the Statistic Registers and their configuration</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:range>0x10</spirit:range>            
                  <spirit:register>
                     <spirit:name>rd2clr_config</spirit:name>
                     <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_err</spirit:name>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_eop_err</spirit:name>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_sop_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80004CA0</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>missing_sop_err</spirit:name>
                     <spirit:description>Counts the number of PTP violations due to missing sop where the srdy was asserted without a prior sop assertion</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>missing_sop_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80004CA4</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>missing_eop_err</spirit:name>
                     <spirit:description>Counts the number of PTP violations due to missing eop where the PTP had been started but a new sop is seen without ending the previously started PTP</spirit:description>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>missing_eop_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80004CA8</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>max_cycle_err</spirit:name>
                     <spirit:description>Counts the number of PTP violations due to reaching the maximum allowed cycles after starting a new PTP</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80004CAC</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004CA0</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 

  <!-- reg group
                    :irq0  --> 
          <spirit:registerFile>
                  <spirit:name>irq0</spirit:name>
                  <spirit:description>Define the IRQ group</spirit:description>
                  <spirit:addressOffset>0x1C</spirit:addressOffset>
                  <spirit:range>0x10</spirit:range>            
                  <spirit:register>
                     <spirit:name>enable</spirit:name>
                     <spirit:description>The enable for the actual interrupt signals. Writing a 1 enables the interrupt.
</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_err</spirit:name>
                        <spirit:description>Fires on PTP violations due to reaching the maximum allowed cycles after starting a new PTP</spirit:description>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_eop_err</spirit:name>
                        <spirit:description>Fires on PTP violations due to missing eop where the PTP had been started but a new sop is seen without ending the previously started PTP</spirit:description>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_sop_err</spirit:name>
                        <spirit:description>Fires on PTP violations due to missing sop where the srdy was asserted without a prior sop assertion</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004CB0</address>
                           <intr.enable>irq666_ptp_guard_2core</intr.enable>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>pending</spirit:name>
                     <spirit:description>The actual interrupt(s) that has triggered. Write a 1 to clear.
</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_err</spirit:name>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_eop_err</spirit:name>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_sop_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004CB4</address>
                           <intr.status>irq666_ptp_guard_2core</intr.status>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>pending_irq</spirit:name>
                     <spirit:description>Registered version of pending &amp; enable.
</spirit:description>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_err</spirit:name>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_eop_err</spirit:name>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_sop_err</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004CB8</address>
                           <intr.pending>irq666_ptp_guard_2core</intr.pending>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>raw</spirit:name>
                     <spirit:description>The status registered values for the interrupt signals, if applicable.</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>max_cycle_err</spirit:name>
                        <spirit:description>Not used</spirit:description>
                        <spirit:bitOffset>2</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_eop_err</spirit:name>
                        <spirit:description>Not used</spirit:description>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>missing_sop_err</spirit:name>
                        <spirit:description>Not used</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004CBC</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004CB0</address>
                        <context>ptp_guard_2core</context>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : irq0  --> 
<spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004C94</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : ptp_guard_2core  --> 

  <!-- reg group
                    :buff_2ulp  --> 
          <spirit:registerFile>
               <spirit:name>buff_2ulp</spirit:name>
               <spirit:addressOffset>0xC0</spirit:addressOffset>
               <spirit:range>0x10</spirit:range>            
               <spirit:register>
                  <spirit:name>control</spirit:name>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>clr</spirit:name>
                     <spirit:description>Clear for both clock domains (write and read)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004CC0</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                  <spirit:name>stats0</spirit:name>
                  <spirit:description>All the Statistic Registers and their configuration for the Write Engine</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:range>0xC</spirit:range>            
                  <spirit:register>
                     <spirit:name>rd2clr_config</spirit:name>
                     <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>pfifo_dcount</spirit:name>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>nfifo_dcount</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80004CC4</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>nfifo_dcount</spirit:name>
                     <spirit:description>Current level for the notification FIFO in the PFIFO</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>nfifo_dcount</spirit:name>
                        <spirit:description>_icron_water_marker_
_icron_no_counter_</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80004CC8</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>pfifo_dcount</spirit:name>
                     <spirit:description>Current level for the packet FIFO in the PFIFO</spirit:description>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>pfifo_dcount</spirit:name>
                        <spirit:description>_icron_water_marker_
_icron_no_counter_</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80004CCC</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004CC4</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 
<spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004CC0</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : buff_2ulp  --> 

  <!-- reg group
                    :buff_2upp  --> 
          <spirit:registerFile>
               <spirit:name>buff_2upp</spirit:name>
               <spirit:addressOffset>0xD0</spirit:addressOffset>
               <spirit:range>0x10</spirit:range>            
               <spirit:register>
                  <spirit:name>control</spirit:name>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>clr</spirit:name>
                     <spirit:description>Clear for both clock domains (write and read)</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004CD0</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                  <spirit:name>stats0</spirit:name>
                  <spirit:description>All the Statistic Registers and their configuration for the Read Engine</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:range>0xC</spirit:range>            
                  <spirit:register>
                     <spirit:name>rd2clr_config</spirit:name>
                     <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>pfifo_scount</spirit:name>
                        <spirit:bitOffset>1</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:field>
                        <spirit:name>nfifo_scount</spirit:name>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>1</spirit:bitWidth>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:access>read-write</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80004CD4</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>nfifo_scount</spirit:name>
                     <spirit:description>Current level for the notification FIFO in the PFIFO</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>nfifo_scount</spirit:name>
                        <spirit:description>_icron_water_marker_
_icron_no_counter_</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80004CD8</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>            
                  <spirit:register>
                     <spirit:name>pfifo_scount</spirit:name>
                     <spirit:description>Current level for the packet FIFO in the PFIFO</spirit:description>
                     <spirit:addressOffset>0x8</spirit:addressOffset>
                     <spirit:size>32</spirit:size>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:reset>
                        <spirit:value>0x00000000</spirit:value>
                        <spirit:mask>0xFFFFFFFF</spirit:mask>
                     </spirit:reset>
                     <spirit:field>
                        <spirit:name>pfifo_scount</spirit:name>
                        <spirit:description>_icron_water_marker_
_icron_no_counter_</spirit:description>
                        <spirit:bitOffset>0</spirit:bitOffset>
                        <spirit:bitWidth>16</spirit:bitWidth>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:access>read-only</spirit:access>
                        <spirit:vendorExtensions>
                           <ids:default_value>0000000000000000</ids:default_value>
                        </spirit:vendorExtensions>
                     </spirit:field>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <external>true</external>
                           <address>0x80004CDC</address>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:register>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004CD4</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 
<spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004CD0</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : buff_2upp  --> 

  <!-- reg group
                    :irq0  --> 
          <spirit:registerFile>
               <spirit:name>irq0</spirit:name>
               <spirit:description>Define the IRQ group</spirit:description>
               <spirit:addressOffset>0xE0</spirit:addressOffset>
               <spirit:range>0x10</spirit:range>            
               <spirit:register>
                  <spirit:name>enable</spirit:name>
                  <spirit:description>The enable for the actual interrupt signals. Writing a 1 enables the interrupt.
</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>link_partner_ptp_violated</spirit:name>
                     <spirit:description>Fires on PTP Protocol Violation in the Link Partner Manager</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004CE0</address>
                        <intr.enable>irq0_xusb3</intr.enable>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending</spirit:name>
                  <spirit:description>The actual interrupt(s) that has triggered. Write a 1 to clear.
</spirit:description>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>link_partner_ptp_violated</spirit:name>
                     <spirit:description>Fires on PTP Protocol Violation in the Link Partner Manager</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-write</spirit:access>
                     <spirit:modifiedWriteValue>oneToClear</spirit:modifiedWriteValue>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004CE4</address>
                        <intr.status>irq0_xusb3</intr.status>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>pending_irq</spirit:name>
                  <spirit:description>Registered version of pending &amp; enable
</spirit:description>
                  <spirit:addressOffset>0x8</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>link_partner_ptp_violated</spirit:name>
                     <spirit:description>Fires on PTP Protocol Violation in the Link Partner Manager</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004CE8</address>
                        <intr.pending>irq0_xusb3</intr.pending>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>            
               <spirit:register>
                  <spirit:name>raw</spirit:name>
                  <spirit:description>The status registered values for the interrupt signals, if applicable.</spirit:description>
                  <spirit:addressOffset>0xC</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:volatile>true</spirit:volatile>
                  <spirit:reset>
                     <spirit:value>0x00000000</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>link_partner_ptp_violated</spirit:name>
                     <spirit:description>Not used</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>1</spirit:bitWidth>
                     <spirit:volatile>true</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>0</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004CEC</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004CE0</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : irq0  --> 
         <spirit:vendorExtensions>
               <ids_properties>
                  <module_name>xusb3_regs</module_name>
                  <uvm.package>xusb3_regs_pkg</uvm.package>
                  <reset_type>async</reset_type>
                  <cheader.mask_endianess>little</cheader.mask_endianess>
                  <header.struct_guard>__ASSEMBLER__</header.struct_guard>
                  <explicit_name>true</explicit_name>
                  <vertical_reuse>true</vertical_reuse>
                  <address>0x80004C00</address>
               </ids_properties>
            </spirit:vendorExtensions>
         </spirit:addressBlock>     
         <spirit:addressBlock>     
            <spirit:name>upp</spirit:name>
            <spirit:description>UPP Registers
</spirit:description>  <!-- //
                        block : upp  --> 
            <spirit:baseAddress>0x80004E00</spirit:baseAddress>               
            <spirit:range>0x300</spirit:range>               
            <spirit:width>32</spirit:width>            
            <spirit:register>
               <spirit:name>version</spirit:name>
               <spirit:description>Version:
2.0.0: Adding the Control Transfer Manager and CT-Processor to the Design
3.0.0: Adding the ITP Manager, Endpoint Table, CTIM Time Tag and Skip Function, etc
3.1.0: Adding Max Burst to the Endpoint Table
3.2.0: Changed the Interrupt Pending to avoid blocking the register update when enable is 0
3.3.0: Added pending_irq register and Add Ping and Bulk IN Termination
4.0.0: Adding BInterval and Independent ISO REX Scheduling for Service Interval Binning. Also, add LEX PFIFOs and ITP Registers
4.1.0: Cleanup register map and added ISO Null Queue
4.1.1: Removed mark_debug and also added read pipline for the PFIFO to improve timing
4.2.0: Add interrupts for ISO Device Non-Response.
4.3.0: Add interrupts for PING not responding
4.3.1: Remove Latches
4.4.0: Use CPU Plug IPs rather than stand alone logic for h2d and d2h</spirit:description>
               <spirit:addressOffset>0x0</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00040400</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>major</spirit:name>
                  <spirit:description>Major version</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000100</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>minor</spirit:name>
                  <spirit:description>Minor version</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000100</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>patch</spirit:name>
                  <spirit:description>Patch version</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>8</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-only</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>00000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004E00</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>config0</spirit:name>
               <spirit:addressOffset>0x4</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x00037508</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>ping_non_rspns_cnt</spirit:name>
                  <spirit:description>Every Service Interval when a PING is sent to the device and a PING RESPONSE is not received, a count is incremented. When the counter reaches this value, it will issue an interrupt to software</spirit:description>
                  <spirit:bitOffset>16</spirit:bitOffset>
                  <spirit:bitWidth>4</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0011</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>dp_max_numb_cnt</spirit:name>
                  <spirit:description>This is the total number of full-size DP packets that needs to be allocated in one ITP. This value together with dp_max_time_cnt divide an ITP period into multiple section of available "credits". The "credits" are used to schedule ISO packets such that they don't fall on ITP boundary.</spirit:description>
                  <spirit:bitOffset>9</spirit:bitOffset>
                  <spirit:bitWidth>7</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0111010</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>dp_max_time_cnt</spirit:name>
                  <spirit:description>Maximum "cycle" time for one DP packet. This is typically 2.117 us and for our 4-byte implementation and clock period of 8 ns (125MHz frequency) it is about 264. This counter value with the help of dp_max_numb_cnt divide an ITP period into multiple sections of available "credits". The "credits" are used to schedule ISO packets such that they don't fall on ITP boundary.</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>9</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>100001000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004E04</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>            
            <spirit:register>
               <spirit:name>control</spirit:name>
               <spirit:addressOffset>0x8</spirit:addressOffset>
               <spirit:size>32</spirit:size>
               <spirit:volatile>false</spirit:volatile>
               <spirit:reset>
                  <spirit:value>0x4ED10180</spirit:value>
                  <spirit:mask>0xFFFFFFFF</spirit:mask>
               </spirit:reset>
               <spirit:field>
                  <spirit:name>limit_num_pings_snt</spirit:name>
                  <spirit:description>Set to 1 to limit the number of PING Request sent to one PING in every 2ms (when device is not responding to PING). To avoid flooding the REX Hub that can cause credit_hp_timer firing, the default is enabled such that it only sends a PING requests every ~2ms when device is not responding (when device is disconnected).</spirit:description>
                  <spirit:bitOffset>30</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>1</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>iso_dev_non_rspns_cnt</spirit:name>
                  <spirit:description>Every Service Interval when the device is asked for data and it does not respond at least with one DP, a count is incremented. When the counter reaches this value, it will issue an interrupt to software.</spirit:description>
                  <spirit:bitOffset>26</spirit:bitOffset>
                  <spirit:bitWidth>4</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0011</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>lex_buff_max_cnt</spirit:name>
                  <spirit:description>This is maximum full DP size of the LEX buffers in each ISO (accelerated) queue. This is used on the REX to follow the buffer occupancy on the LEX. Typical value should be less than 45</spirit:description>
                  <spirit:bitOffset>20</spirit:bitOffset>
                  <spirit:bitWidth>6</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>101101</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>disable_itp_delta</spirit:name>
                  <spirit:description>Set to 1 to disable modifying the ITP Delta field in the Isochronous Timestamp (ITS) of Table 8-26 Section 8.7.</spirit:description>
                  <spirit:bitOffset>19</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>max_itp_deviation_2fix</spirit:name>
                  <spirit:description>Maximum deviation of incoming ITP from Bus Boundary for the ITP Manager to fix immediately. This number should be (deviation us/8 ns). Default value of 128 represents about 1us deviation</spirit:description>
                  <spirit:bitOffset>9</spirit:bitOffset>
                  <spirit:bitWidth>10</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0010000000</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>limit_max_burst</spirit:name>
                  <spirit:description>Set to 0 to let the REX ISO Scheduler to base its burst size on the device Max Burst. By default, the burst size follows the host value.</spirit:description>
                  <spirit:bitOffset>8</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>1</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>bulk_term_en</spirit:name>
                  <spirit:description>Set to 0 to disable BULK IN Termination Method (BITM)</spirit:description>
                  <spirit:bitOffset>7</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>1</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>ping_term_en</spirit:name>
                  <spirit:description>Set to 1 to enable the Ping Termination Method (PTM) that terminates the PING protocol in UPP</spirit:description>
                  <spirit:bitOffset>6</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>ctrl_trfr_int_mode</spirit:name>
                  <spirit:description>When 0, the ctrl_trfr (h2d and d2h) interrupts are packet based (rising sop). 
When 1, the interrupt is cycle based (each srdy causes interrupt)</spirit:description>
                  <spirit:bitOffset>5</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>init_ept</spirit:name>
                  <spirit:description>Assert high to clear and initialize the EndPoint Table (EPT).</spirit:description>
                  <spirit:bitOffset>4</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>itp_gen</spirit:name>
                  <spirit:description>Assert high to instruct the ITP Manager on the REX, when it is enabled, to independently start sending ITP packets to the device as soon as its Link Layer is in U0.</spirit:description>
                  <spirit:bitOffset>3</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>itp_manager_en</spirit:name>
                  <spirit:description>Assert high to have the ITP Manager on the REX enabled such that it can track the ITPs from the Host and independently issue an ITP when the 125us timer elapses and no ITP is received.</spirit:description>
                  <spirit:bitOffset>2</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>ctrl_manager_en</spirit:name>
                  <spirit:description>Assert high to enable the Control Transfer Manager. When not enabled, the UPP does not interfere with or terminate Control Transfers. As the result, Host and Device will interact directly.</spirit:description>
                  <spirit:bitOffset>1</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:field>
                  <spirit:name>clr_ctrl_trfr_mgr</spirit:name>
                  <spirit:description>Assert high to clear all the state tables in the Control Transfer Manager</spirit:description>
                  <spirit:bitOffset>0</spirit:bitOffset>
                  <spirit:bitWidth>1</spirit:bitWidth>
                  <spirit:volatile>false</spirit:volatile>
                  <spirit:access>read-write</spirit:access>
                  <spirit:vendorExtensions>
                     <ids:default_value>0</ids:default_value>
                  </spirit:vendorExtensions>
               </spirit:field>
               <spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004E08</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:register>
  <!-- reg group
                    :id_mgr_fifo  --> 
          <spirit:registerFile>
               <spirit:name>id_mgr_fifo</spirit:name>
               <spirit:addressOffset>0xC</spirit:addressOffset>
               <spirit:range>0x50</spirit:range>            
               <spirit:register>
                  <spirit:name>version</spirit:name>
                  <spirit:description>Version 1.1.0: Added Icron Attributes for stats script generation</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00010100</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>major</spirit:name>
                     <spirit:description>Major version</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000001</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>minor</spirit:name>
                     <spirit:description>Minor version</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000001</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>patch</spirit:name>
                     <spirit:description>Patch version</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004E0C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
  <!-- reg group
                    :write_engine  --> 
          <spirit:registerFile>
                  <spirit:name>write_engine</spirit:name>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:range>0x38</spirit:range>
  <!-- reg group
                    :config0  --> 
          <spirit:registerFile>
                     <spirit:name>config0</spirit:name>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:range>0xC</spirit:range>            
                     <spirit:register>
                        <spirit:name>clear</spirit:name>
                        <spirit:description>Synchronous clear for the write clock domain</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>wclr</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80004E10</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>mode</spirit:name>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000005</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>drp_on_sop</spirit:name>
                           <spirit:description>When set, drops the current packet without writing it to the buffer. See Wiki</spirit:description>
                           <spirit:bitOffset>3</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>drp_on_pkt_err</spirit:name>
                           <spirit:description>When set, removes the packet from the buffer without presenting it to the output interface upon the ERR bit being set before the notification point. See Wiki</spirit:description>
                           <spirit:bitOffset>2</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>1</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pkt_strm</spirit:name>
                           <spirit:description>Selects packet based or streaming based behavior. See Wiki</spirit:description>
                           <spirit:bitOffset>1</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>flw_ctrl_en</spirit:name>
                           <spirit:description>Enables the flow control. See Wiki</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>1</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80004E14</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>notify_limit</spirit:name>
                        <spirit:addressOffset>0x8</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>ntfy_lmt</spirit:name>
                           <spirit:description>Sets the number of words required to be written into the packet FIFO before a notification will be generated. See wiki</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>32</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000000000000000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80004E18</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004E10</address>
                           <context>id_mgr_fifo_write_engine</context>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : config0  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                     <spirit:name>stats0</spirit:name>
                     <spirit:description>All the Statistic Registers and their configuration for the Write Engine</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:range>0x2C</spirit:range>            
                     <spirit:register>
                        <spirit:name>rd2clr_config</spirit:name>
                        <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:bitOffset>9</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>drp_pkt_wr</spirit:name>
                           <spirit:bitOffset>8</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>drp_pkt_rd</spirit:name>
                           <spirit:bitOffset>7</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>wflush_act</spirit:name>
                           <spirit:bitOffset>6</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pkt_sop_err</spirit:name>
                           <spirit:bitOffset>5</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pkt_err</spirit:name>
                           <spirit:bitOffset>4</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>fifo_full_err</spirit:name>
                           <spirit:bitOffset>3</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pkt_max_byte_cnt_err</spirit:name>
                           <spirit:bitOffset>2</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pfifo_dcount</spirit:name>
                           <spirit:bitOffset>1</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>nfifo_dcount</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004E1C</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>nfifo_dcount</spirit:name>
                        <spirit:description>Current level for the notification FIFO in the PFIFO</spirit:description>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>nfifo_dcount</spirit:name>
                           <spirit:description>_icron_water_marker_
_icron_no_counter_</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004E20</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pfifo_dcount</spirit:name>
                        <spirit:description>Current level for the packet FIFO in the PFIFO</spirit:description>
                        <spirit:addressOffset>0x8</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>pfifo_dcount</spirit:name>
                           <spirit:description>_icron_water_marker_
_icron_no_counter_</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004E24</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pkt_max_byte_cnt_err</spirit:name>
                        <spirit:description>The count for capped packets in PFIFO write engine, as the result of reaching maximum size in the PFIFO</spirit:description>
                        <spirit:addressOffset>0xC</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>pkt_max_byte_cnt_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004E28</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>fifo_full_err</spirit:name>
                        <spirit:description>The count for either of PFIFO or NFIFO being full</spirit:description>
                        <spirit:addressOffset>0x10</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>fifo_full_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004E2C</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pkt_err</spirit:name>
                        <spirit:description>The count of packets tagged to be dropped later in the PFIFO read engine</spirit:description>
                        <spirit:addressOffset>0x14</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>pkt_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004E30</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pkt_sop_err</spirit:name>
                        <spirit:description>The count of packets flushed in the PFIFO during the SOP phase</spirit:description>
                        <spirit:addressOffset>0x18</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>pkt_sop_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004E34</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>wflush_act</spirit:name>
                        <spirit:description>The count of capped packets in the PFIFO. Note that back-to-back packets are counted as one if they are both capped.</spirit:description>
                        <spirit:addressOffset>0x1C</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>wflush_act</spirit:name>
                           <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004E38</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>drp_pkt_rd</spirit:name>
                        <spirit:description>The count of drop packets flagged to be dropped by the read engine</spirit:description>
                        <spirit:addressOffset>0x20</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>drp_pkt_rd</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004E3C</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>drp_pkt_wr</spirit:name>
                        <spirit:description>The count of drop packets by the write engine</spirit:description>
                        <spirit:addressOffset>0x24</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>drp_pkt_wr</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004E40</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>flow_ctrl</spirit:name>
                        <spirit:description>The count of the clock cycles the DRDY is asserted low resulting in flow control</spirit:description>
                        <spirit:addressOffset>0x28</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004E44</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004E1C</address>
                           <context>id_mgr_fifo_write_engine</context>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 
<spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004E10</address>
                        <context>id_mgr_fifo</context>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : write_engine  --> 

  <!-- reg group
                    :read_engine  --> 
          <spirit:registerFile>
                  <spirit:name>read_engine</spirit:name>
                  <spirit:addressOffset>0x3C</spirit:addressOffset>
                  <spirit:range>0x14</spirit:range>
  <!-- reg group
                    :config0  --> 
          <spirit:registerFile>
                     <spirit:name>config0</spirit:name>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:range>0x4</spirit:range>            
                     <spirit:register>
                        <spirit:name>clear</spirit:name>
                        <spirit:description>Synchronous clear for the read clock domain</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>rclr</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80004E48</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004E48</address>
                           <context>id_mgr_fifo_read_engine</context>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : config0  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                     <spirit:name>stats0</spirit:name>
                     <spirit:description>All the Statistic Registers and their configuration for the Read Engine</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:range>0x10</spirit:range>            
                     <spirit:register>
                        <spirit:name>rd2clr_config</spirit:name>
                        <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:bitOffset>2</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>drp_pkt</spirit:name>
                           <spirit:bitOffset>1</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>rflush_act</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004E4C</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>rflush_act</spirit:name>
                        <spirit:description>The counts of number of packets flushed from the PFIFO.</spirit:description>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>rflush_act</spirit:name>
                           <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004E50</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>drp_pkt</spirit:name>
                        <spirit:description>The counts of drop packet in the PFIFO read engine</spirit:description>
                        <spirit:addressOffset>0x8</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>drp_pkt</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004E54</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>flow_ctrl</spirit:name>
                        <spirit:description>The count of the clock cycles the DRDY is asserted low resulting in flow control</spirit:description>
                        <spirit:addressOffset>0xC</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004E58</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004E4C</address>
                           <context>id_mgr_fifo_read_engine</context>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 
<spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004E48</address>
                        <context>id_mgr_fifo</context>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : read_engine  --> 
<spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004E0C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : id_mgr_fifo  --> 

  <!-- reg group
                    :iso_lex_fifo_0  --> 
          <spirit:registerFile>
               <spirit:name>iso_lex_fifo_0</spirit:name>
               <spirit:addressOffset>0x5C</spirit:addressOffset>
               <spirit:range>0x50</spirit:range>            
               <spirit:register>
                  <spirit:name>version</spirit:name>
                  <spirit:description>Version 1.1.0: Added Icron Attributes for stats script generation</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00010100</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>major</spirit:name>
                     <spirit:description>Major version</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000001</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>minor</spirit:name>
                     <spirit:description>Minor version</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000001</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>patch</spirit:name>
                     <spirit:description>Patch version</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004E5C</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
  <!-- reg group
                    :write_engine  --> 
          <spirit:registerFile>
                  <spirit:name>write_engine</spirit:name>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:range>0x38</spirit:range>
  <!-- reg group
                    :config0  --> 
          <spirit:registerFile>
                     <spirit:name>config0</spirit:name>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:range>0xC</spirit:range>            
                     <spirit:register>
                        <spirit:name>clear</spirit:name>
                        <spirit:description>Synchronous clear for the write clock domain</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>wclr</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80004E60</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>mode</spirit:name>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000005</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>drp_on_sop</spirit:name>
                           <spirit:description>When set, drops the current packet without writing it to the buffer. See Wiki</spirit:description>
                           <spirit:bitOffset>3</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>drp_on_pkt_err</spirit:name>
                           <spirit:description>When set, removes the packet from the buffer without presenting it to the output interface upon the ERR bit being set before the notification point. See Wiki</spirit:description>
                           <spirit:bitOffset>2</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>1</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pkt_strm</spirit:name>
                           <spirit:description>Selects packet based or streaming based behavior. See Wiki</spirit:description>
                           <spirit:bitOffset>1</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>flw_ctrl_en</spirit:name>
                           <spirit:description>Enables the flow control. See Wiki</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>1</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80004E64</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>notify_limit</spirit:name>
                        <spirit:addressOffset>0x8</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>ntfy_lmt</spirit:name>
                           <spirit:description>Sets the number of words required to be written into the packet FIFO before a notification will be generated. See wiki</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>32</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000000000000000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80004E68</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004E60</address>
                           <context>iso_lex_fifo_0_write_engine</context>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : config0  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                     <spirit:name>stats0</spirit:name>
                     <spirit:description>All the Statistic Registers and their configuration for the Write Engine</spirit:description>
                     <spirit:addressOffset>0xC</spirit:addressOffset>
                     <spirit:range>0x2C</spirit:range>            
                     <spirit:register>
                        <spirit:name>rd2clr_config</spirit:name>
                        <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:bitOffset>9</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>drp_pkt_wr</spirit:name>
                           <spirit:bitOffset>8</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>drp_pkt_rd</spirit:name>
                           <spirit:bitOffset>7</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>wflush_act</spirit:name>
                           <spirit:bitOffset>6</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pkt_sop_err</spirit:name>
                           <spirit:bitOffset>5</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pkt_err</spirit:name>
                           <spirit:bitOffset>4</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>fifo_full_err</spirit:name>
                           <spirit:bitOffset>3</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pkt_max_byte_cnt_err</spirit:name>
                           <spirit:bitOffset>2</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pfifo_dcount</spirit:name>
                           <spirit:bitOffset>1</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>nfifo_dcount</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004E6C</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>nfifo_dcount</spirit:name>
                        <spirit:description>Current level for the notification FIFO in the PFIFO</spirit:description>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>nfifo_dcount</spirit:name>
                           <spirit:description>_icron_water_marker_
_icron_no_counter_</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004E70</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pfifo_dcount</spirit:name>
                        <spirit:description>Current level for the packet FIFO in the PFIFO</spirit:description>
                        <spirit:addressOffset>0x8</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>pfifo_dcount</spirit:name>
                           <spirit:description>_icron_water_marker_
_icron_no_counter_</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004E74</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pkt_max_byte_cnt_err</spirit:name>
                        <spirit:description>The count for capped packets in PFIFO write engine, as the result of reaching maximum size in the PFIFO</spirit:description>
                        <spirit:addressOffset>0xC</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>pkt_max_byte_cnt_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004E78</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>fifo_full_err</spirit:name>
                        <spirit:description>The count for either of PFIFO or NFIFO being full</spirit:description>
                        <spirit:addressOffset>0x10</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>fifo_full_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004E7C</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pkt_err</spirit:name>
                        <spirit:description>The count of packets tagged to be dropped later in the PFIFO read engine</spirit:description>
                        <spirit:addressOffset>0x14</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>pkt_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004E80</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>pkt_sop_err</spirit:name>
                        <spirit:description>The count of packets flushed in the PFIFO during the SOP phase</spirit:description>
                        <spirit:addressOffset>0x18</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>pkt_sop_err</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004E84</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>wflush_act</spirit:name>
                        <spirit:description>The count of capped packets in the PFIFO. Note that back-to-back packets are counted as one if they are both capped.</spirit:description>
                        <spirit:addressOffset>0x1C</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>wflush_act</spirit:name>
                           <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004E88</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>drp_pkt_rd</spirit:name>
                        <spirit:description>The count of drop packets flagged to be dropped by the read engine</spirit:description>
                        <spirit:addressOffset>0x20</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>drp_pkt_rd</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004E8C</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>drp_pkt_wr</spirit:name>
                        <spirit:description>The count of drop packets by the write engine</spirit:description>
                        <spirit:addressOffset>0x24</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>drp_pkt_wr</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004E90</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>flow_ctrl</spirit:name>
                        <spirit:description>The count of the clock cycles the DRDY is asserted low resulting in flow control</spirit:description>
                        <spirit:addressOffset>0x28</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004E94</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004E6C</address>
                           <context>iso_lex_fifo_0_write_engine</context>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 
<spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004E60</address>
                        <context>iso_lex_fifo_0</context>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : write_engine  --> 

  <!-- reg group
                    :read_engine  --> 
          <spirit:registerFile>
                  <spirit:name>read_engine</spirit:name>
                  <spirit:addressOffset>0x3C</spirit:addressOffset>
                  <spirit:range>0x14</spirit:range>
  <!-- reg group
                    :config0  --> 
          <spirit:registerFile>
                     <spirit:name>config0</spirit:name>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:range>0x4</spirit:range>            
                     <spirit:register>
                        <spirit:name>clear</spirit:name>
                        <spirit:description>Synchronous clear for the read clock domain</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>rclr</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80004E98</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004E98</address>
                           <context>iso_lex_fifo_0_read_engine</context>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : config0  --> 

  <!-- reg group
                    :stats0  --> 
          <spirit:registerFile>
                     <spirit:name>stats0</spirit:name>
                     <spirit:description>All the Statistic Registers and their configuration for the Read Engine</spirit:description>
                     <spirit:addressOffset>0x4</spirit:addressOffset>
                     <spirit:range>0x10</spirit:range>            
                     <spirit:register>
                        <spirit:name>rd2clr_config</spirit:name>
                        <spirit:description>Configures if the stats register read by s/w clears the read register.
A 1 in any bit configures the h/w to clear the corresponding stats register after a s/w read of that stats register.</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:bitOffset>2</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>drp_pkt</spirit:name>
                           <spirit:bitOffset>1</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>rflush_act</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004E9C</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>rflush_act</spirit:name>
                        <spirit:description>The counts of number of packets flushed from the PFIFO.</spirit:description>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>rflush_act</spirit:name>
                           <spirit:description>_icron_event_detect_rising_edge_</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004EA0</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>drp_pkt</spirit:name>
                        <spirit:description>The counts of drop packet in the PFIFO read engine</spirit:description>
                        <spirit:addressOffset>0x8</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>drp_pkt</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>8</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>00000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004EA4</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>flow_ctrl</spirit:name>
                        <spirit:description>The count of the clock cycles the DRDY is asserted low resulting in flow control</spirit:description>
                        <spirit:addressOffset>0xC</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>true</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>flow_ctrl</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>16</spirit:bitWidth>
                           <spirit:volatile>true</spirit:volatile>
                           <spirit:access>read-only</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0000000000000000</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <external>true</external>
                              <address>0x80004EA8</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>
                     <spirit:vendorExtensions>
                        <ids_properties>
                           <address>0x80004E9C</address>
                           <context>iso_lex_fifo_0_read_engine</context>
                        </ids_properties>
                     </spirit:vendorExtensions>
                  </spirit:registerFile>  <!-- end
                of reg group : stats0  --> 
<spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004E98</address>
                        <context>iso_lex_fifo_0</context>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:registerFile>  <!-- end
                of reg group : read_engine  --> 
<spirit:vendorExtensions>
                  <ids_properties>
                     <address>0x80004E5C</address>
                  </ids_properties>
               </spirit:vendorExtensions>
            </spirit:registerFile>  <!-- end
                of reg group : iso_lex_fifo_0  --> 

  <!-- reg group
                    :iso_lex_fifo_1  --> 
          <spirit:registerFile>
               <spirit:name>iso_lex_fifo_1</spirit:name>
               <spirit:addressOffset>0xAC</spirit:addressOffset>
               <spirit:range>0x50</spirit:range>            
               <spirit:register>
                  <spirit:name>version</spirit:name>
                  <spirit:description>Version 1.1.0: Added Icron Attributes for stats script generation</spirit:description>
                  <spirit:addressOffset>0x0</spirit:addressOffset>
                  <spirit:size>32</spirit:size>
                  <spirit:reset>
                     <spirit:value>0x00010100</spirit:value>
                     <spirit:mask>0xFFFFFFFF</spirit:mask>
                  </spirit:reset>
                  <spirit:field>
                     <spirit:name>major</spirit:name>
                     <spirit:description>Major version</spirit:description>
                     <spirit:bitOffset>16</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000001</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>minor</spirit:name>
                     <spirit:description>Minor version</spirit:description>
                     <spirit:bitOffset>8</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000001</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:field>
                     <spirit:name>patch</spirit:name>
                     <spirit:description>Patch version</spirit:description>
                     <spirit:bitOffset>0</spirit:bitOffset>
                     <spirit:bitWidth>8</spirit:bitWidth>
                     <spirit:volatile>false</spirit:volatile>
                     <spirit:access>read-only</spirit:access>
                     <spirit:vendorExtensions>
                        <ids:default_value>00000000</ids:default_value>
                     </spirit:vendorExtensions>
                  </spirit:field>
                  <spirit:vendorExtensions>
                     <ids_properties>
                        <address>0x80004EAC</address>
                     </ids_properties>
                  </spirit:vendorExtensions>
               </spirit:register>
  <!-- reg group
                    :write_engine  --> 
          <spirit:registerFile>
                  <spirit:name>write_engine</spirit:name>
                  <spirit:addressOffset>0x4</spirit:addressOffset>
                  <spirit:range>0x38</spirit:range>
  <!-- reg group
                    :config0  --> 
          <spirit:registerFile>
                     <spirit:name>config0</spirit:name>
                     <spirit:addressOffset>0x0</spirit:addressOffset>
                     <spirit:range>0xC</spirit:range>            
                     <spirit:register>
                        <spirit:name>clear</spirit:name>
                        <spirit:description>Synchronous clear for the write clock domain</spirit:description>
                        <spirit:addressOffset>0x0</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000000</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>wclr</spirit:name>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80004EB0</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>mode</spirit:name>
                        <spirit:addressOffset>0x4</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
                        <spirit:volatile>false</spirit:volatile>
                        <spirit:reset>
                           <spirit:value>0x00000005</spirit:value>
                           <spirit:mask>0xFFFFFFFF</spirit:mask>
                        </spirit:reset>
                        <spirit:field>
                           <spirit:name>drp_on_sop</spirit:name>
                           <spirit:description>When set, drops the current packet without writing it to the buffer. See Wiki</spirit:description>
                           <spirit:bitOffset>3</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>drp_on_pkt_err</spirit:name>
                           <spirit:description>When set, removes the packet from the buffer without presenting it to the output interface upon the ERR bit being set before the notification point. See Wiki</spirit:description>
                           <spirit:bitOffset>2</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>1</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>pkt_strm</spirit:name>
                           <spirit:description>Selects packet based or streaming based behavior. See Wiki</spirit:description>
                           <spirit:bitOffset>1</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>0</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:field>
                           <spirit:name>flw_ctrl_en</spirit:name>
                           <spirit:description>Enables the flow control. See Wiki</spirit:description>
                           <spirit:bitOffset>0</spirit:bitOffset>
                           <spirit:bitWidth>1</spirit:bitWidth>
                           <spirit:volatile>false</spirit:volatile>
                           <spirit:access>read-write</spirit:access>
                           <spirit:vendorExtensions>
                              <ids:default_value>1</ids:default_value>
                           </spirit:vendorExtensions>
                        </spirit:field>
                        <spirit:vendorExtensions>
                           <ids_properties>
                              <address>0x80004EB4</address>
                           </ids_properties>
                        </spirit:vendorExtensions>
                     </spirit:register>            
                     <spirit:register>
                        <spirit:name>notify_limit</spirit:name>
                        <spirit:addressOffset>0x8</spirit:addressOffset>
                        <spirit:size>32</spirit:size>
